options:
  parameters:
    author: methalabeywickrama
    generate_options: qt_gui
    id: hardware_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: int(48000)
  states: {}
- name: ch_gain
  id: variable_qtgui_range
  parameters:
    label: 'Channel Gain '
    start: '10'
    step: '1'
    stop: '65'
    value: '50'
  states: {}
- name: costas_bw
  id: variable_qtgui_range
  parameters:
    label: Costas BW
    start: '0.001'
    step: '0.0001'
    stop: '0.01'
    value: '0.005'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: int(48e4)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 100e6
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(quad_rate)
    interp: int(samp_rate)
    type: ccc
  states: {state: disabled}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: 100e3
    center_freq: 433.92e6
    dev_args: '"driver=bladerf"'
    gain: '65'
    samp_rate: 2e6
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: 100e6
    dev_args: '"driver=bladerf"'
    gain: '40.0'
    samp_rate: 2e6
    type: fc32
  states: {state: disabled}
- name: transeciever_0
  id: transeciever
  parameters:
    ADDR: '"192.168.1.1"'
    CH_GAIN: ch_gain
    SDR_CF: 433.92e6
    alpha: '0.45'
    costas_bw: 2 * 3.1415926 * costas_bw
    fll_loop_bw: 2 * 3.1415926 * 0.001
    nfilts: '32'
    samp_rate: 2e6
    sps: '4'
  states: {}

connections:
- [analog_random_source_x_0, '0', transeciever_0, '0']
- [analog_sig_source_x_0, '0', analog_wfm_tx_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', soapy_bladerf_sink_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [transeciever_0, '0', blocks_char_to_float_0, '0']
- [transeciever_0, '1', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
