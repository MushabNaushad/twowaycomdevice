options:
  parameters:
    generate_options: qt_gui
    id: test_transport
    output_language: python
    title: Transport Layer Test
  states: {}

blocks:
- name: flag
  id: variable
  parameters:
    value: '126'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: DLC_addFlags_0
  id: DLC_addFlags
  parameters:
    bothEnds: 'True'
    flag: flag
  states: {}
- name: DLC_addFlags_0_0
  id: DLC_addFlags
  parameters:
    bothEnds: 'True'
    flag: flag
  states: {}
- name: DLC_bitStuffing_0
  id: DLC_bitStuffing
  parameters:
    flag: '126'
  states: {}
- name: DLC_bitStuffing_0_0
  id: DLC_bitStuffing
  parameters:
    flag: '126'
  states: {}
- name: DLC_deStuffing_0
  id: DLC_deStuffing
  parameters:
    flag: '126'
  states: {}
- name: DLC_deStuffing_0_0
  id: DLC_deStuffing
  parameters:
    flag: '126'
  states: {}
- name: DLC_removeFlags_0
  id: DLC_removeFlags
  parameters:
    flag: flag
  states: {}
- name: DLC_removeFlags_0_0
  id: DLC_removeFlags
  parameters:
    flag: flag
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(25, [2, 1, 1, 0, 0, 0, 0, 17] + [ord(c) for c in "Hello from Strobe"]))
    period: '2000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '1000'
    type: complex
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: digital_crc32_async_bb_0_0
  id: digital_crc32_async_bb
  parameters:
    check: 'True'
  states: {}
- name: transport_transport_layer_0
  id: transport_transport_layer
  parameters:
    local_addr: '0'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"initiator"'
    rto_ms: '500'
  states: {}
- name: transport_transport_layer_1
  id: transport_transport_layer
  parameters:
    local_addr: '0'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"responder"'
    rto_ms: '500'
  states: {}

connections:
- [DLC_addFlags_0, out, DLC_removeFlags_0, pdu_in]
- [DLC_addFlags_0_0, out, DLC_removeFlags_0_0, pdu_in]
- [DLC_bitStuffing_0, out, DLC_addFlags_0, in]
- [DLC_bitStuffing_0_0, out, DLC_addFlags_0_0, in]
- [DLC_deStuffing_0, out, digital_crc32_async_bb_0_0, in]
- [DLC_deStuffing_0_0, out, transport_transport_layer_0, pdu_in]
- [DLC_removeFlags_0, pdu_out, DLC_deStuffing_0, in]
- [DLC_removeFlags_0_0, pdu_out, DLC_deStuffing_0_0, in]
- [blocks_message_strobe_0, strobe, transport_transport_layer_0, app_in]
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [digital_crc32_async_bb_0, out, DLC_bitStuffing_0, in]
- [digital_crc32_async_bb_0_0, out, transport_transport_layer_1, pdu_in]
- [transport_transport_layer_0, app_out, blocks_message_debug_0, print_pdu]
- [transport_transport_layer_0, pdu_out, digital_crc32_async_bb_0, in]
- [transport_transport_layer_1, app_out, blocks_message_debug_0, print_pdu]
- [transport_transport_layer_1, pdu_out, DLC_bitStuffing_0_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
