options:
  parameters:
    author: maduwage
    generate_options: hb
    id: DLCtx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: DLC_CRCGen_0
  id: DLC_CRCGen
  parameters:
    scheme: '8'
  states: {}
- name: DLC_addFlags_0
  id: DLC_addFlags
  parameters:
    bothEnds: 'True'
    flag: '126'
  states: {}
- name: DLC_bitStuffing_0
  id: DLC_bitStuffing
  parameters:
    flag: '126'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: message
  states: {}

connections:
- [DLC_CRCGen_0, out, DLC_bitStuffing_0, in]
- [DLC_addFlags_0, out, pad_sink_0, in]
- [DLC_bitStuffing_0, out, DLC_addFlags_0, in]
- [pad_source_0, out, DLC_CRCGen_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
