options:
  parameters:
    author: maduwage
    generate_options: qt_gui
    id: crctest
    output_language: python
    title: CRC test
  states: {}

blocks:
- name: flag
  id: variable
  parameters:
    value: '126'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: DLC_CRCCheck_0
  id: DLC_CRCCheck
  parameters:
    scheme: '8'
  states: {}
- name: DLC_CRCGen_0
  id: DLC_CRCGen
  parameters:
    scheme: '8'
  states: {}
- name: DLC_addFlags_0
  id: DLC_addFlags
  parameters:
    bothEnds: 'True'
    flag: flag
  states: {}
- name: DLC_bitStuffing_0
  id: DLC_bitStuffing
  parameters:
    flag: '126'
  states: {}
- name: DLC_deStuffing_0
  id: DLC_deStuffing
  parameters:
    flag: '126'
  states: {}
- name: DLC_removeFlags_0
  id: DLC_removeFlags
  parameters:
    flag: flag
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '10000'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '1'
    mask: '0xFF'
    maxsize: '2'
    minsize: '1'
  states: {}

connections:
- [DLC_CRCCheck_0, out, blocks_message_debug_0_0_0, print]
- [DLC_CRCGen_0, out, DLC_bitStuffing_0, in]
- [DLC_addFlags_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [DLC_bitStuffing_0, out, DLC_addFlags_0, in]
- [DLC_deStuffing_0, out, DLC_CRCCheck_0, in]
- [DLC_deStuffing_0, out, blocks_message_debug_0_0, print]
- [DLC_removeFlags_0, pdu_out, DLC_deStuffing_0, in]
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [pdu_pdu_to_tagged_stream_0, '0', DLC_removeFlags_0, '0']
- [pdu_random_pdu_0, pdus, DLC_CRCGen_0, in]
- [pdu_random_pdu_0, pdus, blocks_message_debug_0_0_0_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
