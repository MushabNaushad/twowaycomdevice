options:
  parameters:
    author: maduwage
    generate_options: qt_gui
    id: Tranport_DLC_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: CRCpoly
  id: variable
  parameters:
    value: '0x4C11DB7'
  states: {}
- name: flag
  id: variable
  parameters:
    value: '126'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: DLC_CRCCheck_0
  id: DLC_CRCCheck
  parameters:
    scheme: '8'
  states: {state: disabled}
- name: DLC_CRCGen_0
  id: DLC_CRCGen
  parameters:
    scheme: '8'
  states: {state: disabled}
- name: DLC_addFlags_0
  id: DLC_addFlags
  parameters:
    bothEnds: 'True'
    flag: flag
  states: {state: disabled}
- name: DLC_bitStuffing_0
  id: DLC_bitStuffing
  parameters:
    flag: '126'
  states: {state: disabled}
- name: DLC_deStuffing_0
  id: DLC_deStuffing
  parameters:
    flag: '126'
  states: {state: disabled}
- name: DLC_removeFlags_0
  id: DLC_removeFlags
  parameters:
    flag: flag
  states: {state: disabled}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_1_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(25, [171, 205, 1, 0, 0, 0, 0, 17] + [ord(c) for c in "Hello from Strobe"]))
    period: '2000'
  states: {}
- name: transport_transport_layer_0
  id: transport_transport_layer
  parameters:
    m: '4'
    mtu_bytes: '200'
    node_role: '"initiator"'
    rto_ms: '500'
  states: {}
- name: transport_transport_layer_0_0
  id: transport_transport_layer
  parameters:
    m: '4'
    mtu_bytes: '200'
    node_role: '"initiator"'
    rto_ms: '500'
  states: {}

connections:
- [DLC_CRCCheck_0, out, transport_transport_layer_0_0, pdu_in]
- [DLC_CRCGen_0, out, DLC_bitStuffing_0, in]
- [DLC_addFlags_0, out, DLC_removeFlags_0, pdu_in]
- [DLC_bitStuffing_0, out, DLC_addFlags_0, in]
- [DLC_deStuffing_0, out, DLC_CRCCheck_0, in]
- [DLC_removeFlags_0, pdu_out, DLC_deStuffing_0, in]
- [blocks_message_strobe_0, strobe, transport_transport_layer_0, app_in]
- [transport_transport_layer_0, app_out, blocks_message_debug_0_1, print_pdu]
- [transport_transport_layer_0, pdu_out, DLC_CRCGen_0, in]
- [transport_transport_layer_0, pdu_out, transport_transport_layer_0_0, pdu_in]
- [transport_transport_layer_0_0, app_out, blocks_message_debug_0_1_0, print_pdu]
- [transport_transport_layer_0_0, pdu_out, transport_transport_layer_0, pdu_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
