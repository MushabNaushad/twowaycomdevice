options:
  parameters:
    author: mushab404
    generate_options: qt_gui
    id: test
    output_language: python
    title: Test Overall
  states: {}

blocks:
- name: barkercode
  id: variable_header_format_default
  parameters:
    access_code: '"11100010010"'
    bps: '2'
    threshold: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: text
  id: variable
  parameters:
    value: '"HELLO_WORLD! "'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern(text)
    period: '1000'
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: len(text) + 500
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: '"CORR_CHECK"'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[ord(c) for c in text] + [0] * 500'
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100010010"'
    tagname: '''sync_word'''
    threshold: '3'
    type: byte
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: '32'
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"packet_len"'
    output_symbols: 'False'
    samp_rate: samp_rate
    special_tags: '[]'
    timing_tag_key: '"rx_time"'
    trigger_tag_key: '"sync_word"'
    type: byte
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: barkercode
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: barkercode
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import sys

      class blk(gr.sync_block):
          """Prints incoming byte stream as ASCII text to the GRC console"""

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Print Text to Console',
                  in_sig=[np.byte],
                  out_sig=None
              )

          def work(self, input_items, output_items):
              in0 = input_items[0]
              if len(in0) > 0:
                  # Filter for printable ASCII characters and convert
                  text = "".join([chr(c) for c in in0 if 32 <= c <= 126])
                  if text:
                      print(text, end='', flush=True)
              return len(in0)
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    size: '1024 '
    srate: samp_rate
    type: float
  states: {}
- name: transeciever_soft_0
  id: transeciever_soft
  parameters:
    ADDR: '"192.168.1.1"'
    CH_GAIN: '30'
    SDR_CF: 433M
    alpha: '0.45'
    costas_bw: 2 * 3.1415926 * 0.01
    fll_loop_bw: 2 * 3.1415926 * 0.001
    frequency_offset: '0.025'
    nfilts: '32'
    noise_volt: '0.2'
    samp_rate: '32000'
    sps: '4'
    time_offset: '1.005'
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_message_strobe_0, strobe, pdu_pdu_to_tagged_stream_0, pdus]
- [blocks_repack_bits_bb_0, '0', epy_block_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_protocol_parser_b_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', transeciever_soft_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_tag_debug_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', digital_header_payload_demux_0, '0']
- [digital_header_payload_demux_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_header_payload_demux_0, '1', blocks_char_to_float_0, '0']
- [digital_header_payload_demux_0, '1', blocks_repack_bits_bb_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_protocol_parser_b_0, info, digital_header_payload_demux_0, header_data]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [transeciever_soft_0, '0', digital_correlate_access_code_xx_ts_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
