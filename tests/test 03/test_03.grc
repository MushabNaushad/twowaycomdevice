options:
  parameters:
    author: methalabeywickrama
    generate_options: qt_gui
    id: test_03
    output_language: python
    title: Test 03
  states: {}

blocks:
- name: hdr
  id: variable
  parameters:
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: packets
  id: variable
  parameters:
    value: '10'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e5
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: payload_size
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: '[p + 48 for p in range(packets) for _ in range(payload_size)]'
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: '"packet_len"'
    threshold: '3'
    type: byte
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr
    len_tag_key: '"packet_len"'
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: transeciever_soft_0
  id: transeciever_soft
  parameters:
    ADDR: '"192.168.1.1"'
    CH_GAIN: '30'
    SDR_CF: 433M
    alpha: '0.35'
    costas_bw: '0.062'
    fll_loop_bw: '0.045'
    frequency_offset: '0'
    nfilts: '32'
    noise_volt: '0'
    samp_rate: samp_rate
    sps: '4'
    time_offset: '1.00'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: packet
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx_payload
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: packet
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: rx_payload
  states: {}

connections:
- [blocks_repack_bits_bb_0, '0', digital_crc32_bb_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', virtual_sink_1, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [transeciever_soft_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [virtual_source_0, '0', transeciever_soft_0, '0']
- [virtual_source_0_0, '0', blocks_repack_bits_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
