options:
  parameters:
    author: MethalMindiya
    description: In-Band Transport Protocol Serialization Verification on Pure-RF Channel
    generate_options: qt_gui
    id: test_inband_phy
    output_language: python
    run_command: '"/home/methalabeywickrama/Documents/CDP Project/twowaycomdevice/tests/run_inband_phy.sh" {filename}'
    title: In-Band Transport Protocol Header Test (Pure RF Simulation)
  states: {}

blocks:
- name: drop_prob
  id: variable_qtgui_range
  parameters:
    comment: Channel Loss Probability Slider
    gui_hint: 0,0,1,2
    label: '"Channel Loss Rate (p_drop)"'
    min_len: '250'
    start: '0'
    step: '0.05'
    stop: '0.5'
    value: '0.0'
  states: {}
- name: dst_addr
  id: variable
  parameters:
    value: '9'
  states: {}
- name: m
  id: variable
  parameters:
    value: '4'
  states: {}
- name: mtu
  id: variable
  parameters:
    value: '256'
  states: {}
- name: rto_ms
  id: variable
  parameters:
    value: '400'
  states: {}
- name: src_addr
  id: variable
  parameters:
    value: '5'
  states: {}
- name: app_image_generator
  id: epy_block
  parameters:
    _source_code: |
      import pmt, ctypes, os
      from gnuradio import gr

      try:
          so = os.path.abspath(os.path.join(os.path.dirname(__file__), '..', 'blocks', 'gr-transport', 'build', 'lib', 'libgnuradio-transport.so'))
          if os.path.exists(so):
              ctypes.CDLL(so, mode=ctypes.RTLD_GLOBAL)
      except Exception:
          pass

      class blk(gr.basic_block):
          """Generates a multi-chunk Image bitstream with the 8-byte application header."""
          def __init__(self, dst_addr=9, payload_len=1024):
              gr.basic_block.__init__(self, name='App Image Gen', in_sig=None, out_sig=None)
              self.dst_addr = dst_addr
              self.payload_len = payload_len
              self.seq_num = 0
              self.message_port_register_in(pmt.intern('trig'))
              self.message_port_register_out(pmt.intern('app_out'))
              self.set_msg_handler(pmt.intern('trig'), self.handle_trig)

          def handle_trig(self, msg):
              self.seq_num += 1
              img_data = bytes([(i + self.seq_num) % 256 for i in range(self.payload_len)])
              n = len(img_data)
              # 8-Byte Application Header: [dst_addr, port, type=0x02(image), rsv=0, len_u32]
              hdr = bytes([self.dst_addr, 0x00, 0x02, 0x00, (n >> 24) & 0xFF, (n >> 16) & 0xFF, (n >> 8) & 0xFF, n & 0xFF])
              full_frame = list(hdr + img_data)
              pdu = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(full_frame), full_frame))
              print(f"\n[APP TX] Injecting Image Stream #{self.seq_num} ({len(full_frame)}B) to Node {self.dst_addr}", flush=True)
              self.message_port_pub(pmt.intern('app_out'), pdu)
    comment: Constructs 8-byte app header + image bytes
    dst_addr: dst_addr
    payload_len: '1024'
  states: {}
- name: app_strobe
  id: blocks_message_strobe
  parameters:
    comment: Periodic Image Trigger
    msg: pmt.intern('TRIGGER')
    period: '2000'
  states: {}
- name: blocks_message_debug_ini
  id: blocks_message_debug
  parameters:
    comment: Initiator app_out sink
  states: {}
- name: blocks_message_debug_ini_0
  id: blocks_message_debug
  parameters:
    comment: Initiator app_out sink
  states: {}
- name: blocks_message_debug_rx
  id: blocks_message_debug
  parameters:
    comment: Displays Reassembled Application Bitstream at Responder
  states: {}
- name: blocks_null_snk
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_src
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: '1000'
    type: complex
  states: {}
- name: pure_rf_channel_fwd
  id: epy_block
  parameters:
    _source_code: |
      import pmt, random
      from gnuradio import gr

      class blk(gr.basic_block):
          """Pure-RF Physical Channel: Strips PMT metadata dict to test 100% in-band transport."""
          def __init__(self, p_drop=0.0):
              gr.basic_block.__init__(self, name='Pure RF Channel (FWD)', in_sig=None, out_sig=None)
              self.p_drop = p_drop
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def set_p_drop(self, p):
              self.p_drop = p

          def handle_msg(self, msg):
              if not pmt.is_pair(msg):
                  return
              data = pmt.cdr(msg)
              if not pmt.is_u8vector(data):
                  return
              raw = bytes(pmt.u8vector_elements(data))
              if len(raw) < 18:
                  return
              types = {1:'SYN', 2:'SYN_ACK', 3:'DATA', 4:'ACK', 5:'FIN', 6:'FIN_ACK'}
              pkt_type = types.get(raw[0], f'0x{raw[0]:02X}')
              seq = (raw[6] << 8) | raw[7]
              tot = (raw[8] << 8) | raw[9]
              sid = int.from_bytes(raw[10:18], 'big')
              
              if random.random() < self.p_drop:
                  print(f"  [PHY DROP FWD] Type={pkt_type:<7} Length={len(raw):>4}B | Seq={seq} (LOST)", flush=True)
                  return
              
              print(f"  [PHY TX->RX]   Type={pkt_type:<7} Length={len(raw):>4}B | Src={raw[2]} Dst={raw[4]} Seq={seq} Tot={tot} Sid=0x{sid:08X}", flush=True)
              # Wipe metadata dictionary -> pure RF byte reception
              air_pdu = pmt.cons(pmt.make_dict(), data)
              self.message_port_pub(pmt.intern('pdu_out'), air_pdu)
    comment: Simulates over-the-air raw byte channel (0% PMT metadata)
    p_drop: drop_prob
  states: {}
- name: pure_rf_channel_rev
  id: epy_block
  parameters:
    _source_code: |
      import pmt, random
      from gnuradio import gr

      class blk(gr.basic_block):
          """Pure-RF Physical Channel: Strips PMT metadata dict to test 100% in-band transport."""
          def __init__(self, p_drop=0.0):
              gr.basic_block.__init__(self, name='Pure RF Channel (REV)', in_sig=None, out_sig=None)
              self.p_drop = p_drop
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def set_p_drop(self, p):
              self.p_drop = p

          def handle_msg(self, msg):
              if not pmt.is_pair(msg):
                  return
              data = pmt.cdr(msg)
              if not pmt.is_u8vector(data):
                  return
              raw = bytes(pmt.u8vector_elements(data))
              if len(raw) < 18:
                  return
              types = {1:'SYN', 2:'SYN_ACK', 3:'DATA', 4:'ACK', 5:'FIN', 6:'FIN_ACK'}
              pkt_type = types.get(raw[0], f'0x{raw[0]:02X}')
              seq = (raw[6] << 8) | raw[7]
              
              if random.random() < self.p_drop:
                  print(f"  [PHY DROP REV] Type={pkt_type:<7} Length={len(raw):>4}B | Seq={seq} (LOST)", flush=True)
                  return
              
              print(f"  [PHY RX->TX]   Type={pkt_type:<7} Length={len(raw):>4}B | Seq={seq}", flush=True)
              air_pdu = pmt.cons(pmt.make_dict(), data)
              self.message_port_pub(pmt.intern('pdu_out'), air_pdu)
    comment: Reverse channel for ACKs and SYN_ACKs
    p_drop: drop_prob
  states: {}
- name: transport_initiator
  id: transport_transport_layer
  parameters:
    comment: Initiator (Node 5)
    local_addr: src_addr
    local_port: '0'
    m: m
    mtu_bytes: mtu
    node_role: initiator
    rto_ms: rto_ms
  states: {}
- name: transport_responder
  id: transport_transport_layer
  parameters:
    comment: Responder (Node 9)
    local_addr: dst_addr
    local_port: '0'
    m: m
    mtu_bytes: mtu
    node_role: responder
    rto_ms: rto_ms
  states: {}

connections:
- [app_image_generator, app_out, transport_initiator, app_in]
- [app_strobe, strobe, app_image_generator, trig]
- [blocks_null_src, '0', blocks_throttle, '0']
- [blocks_throttle, '0', blocks_null_snk, '0']
- [pure_rf_channel_fwd, pdu_out, transport_responder, pdu_in]
- [pure_rf_channel_rev, pdu_out, transport_initiator, pdu_in]
- [transport_initiator, app_out, blocks_message_debug_ini, store]
- [transport_initiator, pdu_out, blocks_message_debug_ini_0, print_pdu]
- [transport_initiator, pdu_out, pure_rf_channel_fwd, pdu_in]
- [transport_responder, app_out, blocks_message_debug_rx, store]
- [transport_responder, pdu_out, pure_rf_channel_rev, pdu_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
