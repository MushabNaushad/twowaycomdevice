options:
  parameters:
    author: mushab404
    generate_options: qt_gui
    id: test_02
    output_language: python
    title: Transmitter Test 02
  states: {}

blocks:
- name: ch_gain
  id: variable_qtgui_range
  parameters:
    label: Channel Gain
    start: '10'
    step: '1'
    stop: '65'
    value: '50'
  states: {}
- name: costas_bw
  id: variable_qtgui_range
  parameters:
    label: Costas loop Bandwidth
    start: '0.001'
    step: '0.001'
    stop: '0.1'
    value: '0.001'
  states: {}
- name: fll_bw
  id: variable_qtgui_range
  parameters:
    label: 'FLL band edge: Loop Bandwidth'
    start: '0.001'
    step: '0.001'
    stop: '0.1'
    value: '0.001'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sync_delay
  id: variable_qtgui_range
  parameters:
    label: Sync Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '0'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_delay
    type: byte
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(10e5)
    max_iter: '4000'
    scale: '10e-5'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: number_sink
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Current BER"'
    type: float
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: reciever_0
  id: reciever
  parameters:
    ADDR: '"192.168.1.1"'
    CH_GAIN: ch_gain
    SDR_CF: 433e6
    alpha: '0.45'
    costas_bw: 2 * 3.1415926 * costas_bw
    fll_loop_bw: 2 * 3.1415926 * fll_bw
    nfilts: '32'
    samp_rate: '32000'
    sps: '4'
  states: {}
- name: transeciever_soft_0
  id: transeciever_soft
  parameters:
    ADDR: '"192.168.1.1"'
    CH_GAIN: '30'
    SDR_CF: 433M
    alpha: '0.45'
    costas_bw: 2 * 3.1415926 * 0.01
    fll_loop_bw: 2 * 3.1415926 * 0.001
    frequency_offset: '0'
    nfilts: '32'
    noise_volt: '0'
    samp_rate: '32000'
    sps: '4'
    time_offset: '1'
  states: {state: disabled}
- name: transmitter_0
  id: transmitter
  parameters:
    ADDR: '"192.168.1.1"'
    CH_GAIN: ch_gain
    SDR_CF: 433e6
    alpha: '0.45'
    nfilts: '32'
    samp_rate: samp_rate
    sps: '4'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_ref
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_ref
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_copy_0, '0']
- [analog_random_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_abs_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_char_to_float_0, '0', blocks_sub_xx_0, '1']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_copy_0, '0', blocks_throttle2_0, '0']
- [blocks_copy_0, '0', transmitter_0, '0']
- [blocks_delay_0, '0', virtual_sink_0, '0']
- [blocks_moving_average_xx_0, '0', number_sink, '0']
- [blocks_sub_xx_0, '0', blocks_abs_xx_0, '0']
- [blocks_throttle2_0, '0', transeciever_soft_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_delay_0, '0']
- [reciever_0, '0', blocks_char_to_float_0, '0']
- [reciever_0, '1', qtgui_const_sink_x_0, '0']
- [transeciever_soft_0, '0', blocks_char_to_float_0, '0']
- [virtual_source_0, '0', blocks_char_to_float_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
