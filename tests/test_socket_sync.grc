options:
  parameters:
    author: MethalMindiya
    description: Hot-Folder UDP Socket PDU File Sync Flowgraph
    generate_options: qt_gui
    id: test_socket_sync
    output_language: python
    run_command: '"/home/methalabeywickrama/Documents/CDP Project/twowaycomdevice/tests/run_socket_sync.sh" {filename}'
    title: Two-Way Radio Hot-Folder File Sync (Socket PDU Interface)
  states: {}

blocks:
- name: drop_prob
  id: variable_qtgui_range
  parameters:
    comment: RF Channel Loss Rate Slider
    gui_hint: 0,0,1,2
    label: '"Channel Loss Rate (p_drop)"'
    min_len: '250'
    start: '0'
    step: '0.05'
    stop: '0.5'
    value: '0.0'
  states: {}
- name: m
  id: variable
  parameters:
    comment: Sequence width (m=5 -> W=16)
    value: '5'
  states: {}
- name: mtu
  id: variable
  parameters:
    comment: MTU bytes per frame
    value: '500'
  states: {}
- name: rto_ms
  id: variable
  parameters:
    comment: Retransmission timeout (ms)
    value: '400'
  states: {}
- name: blocks_null_snk
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_src
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: '1000'
    type: complex
  states: {}
- name: debug_n1_app_out
  id: blocks_message_debug
  parameters:
    comment: Debug monitor Node 1 app_out
  states: {}
- name: debug_n2_app_out
  id: blocks_message_debug
  parameters:
    comment: Debug monitor Node 2 app_out
  states: {}
- name: pure_rf_channel_fwd
  id: epy_block
  parameters:
    _source_code: |
      import pmt, random
      from gnuradio import gr

      class blk(gr.basic_block):
          """Pure-RF Physical Channel: Strips PMT metadata dict to test 100% in-band transport."""
          def __init__(self, p_drop=0.0):
              gr.basic_block.__init__(self, name='Pure RF Channel (1->2)', in_sig=None, out_sig=None)
              self.p_drop = p_drop
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def set_p_drop(self, p):
              self.p_drop = p

          def handle_msg(self, msg):
              if not pmt.is_pair(msg):
                  return
              data = pmt.cdr(msg)
              if not pmt.is_u8vector(data):
                  return
              raw = bytes(pmt.u8vector_elements(data))
              if len(raw) < 18:
                  return
              types = {1:'SYN', 2:'SYN_ACK', 3:'DATA', 4:'ACK', 5:'FIN', 6:'FIN_ACK'}
              pkt_type = types.get(raw[0], f'0x{raw[0]:02X}')
              seq = (raw[6] << 8) | raw[7]
              tot = (raw[8] << 8) | raw[9]
              sid = int.from_bytes(raw[10:18], 'big')
              
              if random.random() < self.p_drop:
                  print(f"  [RF DROP 1->2] Type={pkt_type:<7} Length={len(raw):>4}B | Seq={seq}", flush=True)
                  return
              
              print(f"  [RF 1->2]      Type={pkt_type:<7} Length={len(raw):>4}B | Src={raw[2]} Dst={raw[4]} Seq={seq} Tot={tot}", flush=True)
              air_pdu = pmt.cons(pmt.make_dict(), data)
              self.message_port_pub(pmt.intern('pdu_out'), air_pdu)
    comment: Simulates over-the-air raw byte channel (0% PMT metadata)
    p_drop: drop_prob
  states: {}
- name: pure_rf_channel_rev
  id: epy_block
  parameters:
    _source_code: |
      import pmt, random
      from gnuradio import gr

      class blk(gr.basic_block):
          """Pure-RF Physical Channel: Strips PMT metadata dict to test 100% in-band transport."""
          def __init__(self, p_drop=0.0):
              gr.basic_block.__init__(self, name='Pure RF Channel (2->1)', in_sig=None, out_sig=None)
              self.p_drop = p_drop
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def set_p_drop(self, p):
              self.p_drop = p

          def handle_msg(self, msg):
              if not pmt.is_pair(msg):
                  return
              data = pmt.cdr(msg)
              if not pmt.is_u8vector(data):
                  return
              raw = bytes(pmt.u8vector_elements(data))
              if len(raw) < 18:
                  return
              types = {1:'SYN', 2:'SYN_ACK', 3:'DATA', 4:'ACK', 5:'FIN', 6:'FIN_ACK'}
              pkt_type = types.get(raw[0], f'0x{raw[0]:02X}')
              seq = (raw[6] << 8) | raw[7]
              
              if random.random() < self.p_drop:
                  print(f"  [RF DROP 2->1] Type={pkt_type:<7} Length={len(raw):>4}B | Seq={seq}", flush=True)
                  return
              
              print(f"  [RF 2->1]      Type={pkt_type:<7} Length={len(raw):>4}B | Seq={seq}", flush=True)
              air_pdu = pmt.cons(pmt.make_dict(), data)
              self.message_port_pub(pmt.intern('pdu_out'), air_pdu)
    comment: Reverse channel for ACKs and SYN_ACKs
    p_drop: drop_prob
  states: {}
- name: socket_pdu_cli_n1
  id: network_socket_pdu
  parameters:
    comment: Sends reassembled files to Node 1 Daemon (rx)
    host: 127.0.0.1
    mtu: '65536'
    port: '52002'
    type: UDP_CLIENT
  states: {}
- name: socket_pdu_cli_n2
  id: network_socket_pdu
  parameters:
    comment: Sends reassembled files to Node 2 Daemon (rx)
    host: 127.0.0.1
    mtu: '65536'
    port: '52004'
    type: UDP_CLIENT
  states: {}
- name: socket_pdu_srv_n1
  id: network_socket_pdu
  parameters:
    comment: Listens for files from Node 1 Daemon (tx)
    host: 127.0.0.1
    mtu: '65536'
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: socket_pdu_srv_n2
  id: network_socket_pdu
  parameters:
    comment: Listens for files from Node 2 Daemon (tx)
    host: 127.0.0.1
    mtu: '65536'
    port: '52003'
    type: UDP_SERVER
  states: {}
- name: transport_n1
  id: transport_transport_layer
  parameters:
    comment: Transport Layer Node 1
    local_addr: '1'
    local_port: '0'
    m: m
    mtu_bytes: mtu
    node_role: initiator
    rto_ms: rto_ms
  states: {}
- name: transport_n2
  id: transport_transport_layer
  parameters:
    comment: Transport Layer Node 2
    local_addr: '2'
    local_port: '0'
    m: m
    mtu_bytes: mtu
    node_role: responder
    rto_ms: rto_ms
  states: {}

connections:
- [blocks_null_src, '0', blocks_throttle, '0']
- [blocks_throttle, '0', blocks_null_snk, '0']
- [pure_rf_channel_fwd, pdu_out, transport_n2, pdu_in]
- [pure_rf_channel_rev, pdu_out, transport_n1, pdu_in]
- [socket_pdu_srv_n1, pdus, transport_n1, app_in]
- [socket_pdu_srv_n2, pdus, transport_n2, app_in]
- [transport_n1, app_out, debug_n1_app_out, store]
- [transport_n1, app_out, socket_pdu_cli_n1, pdus]
- [transport_n1, pdu_out, pure_rf_channel_fwd, pdu_in]
- [transport_n2, app_out, debug_n2_app_out, print_pdu]
- [transport_n2, app_out, socket_pdu_cli_n2, pdus]
- [transport_n2, pdu_out, pure_rf_channel_rev, pdu_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
