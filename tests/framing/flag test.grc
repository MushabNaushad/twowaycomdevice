options:
  parameters:
    generate_options: qt_gui
    id: flagtest
    output_language: python
    title: flagtest
  states: {}

blocks:
- name: flag
  id: variable
  parameters:
    value: '126'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: DLC_addFlags_0
  id: DLC_addFlags
  parameters:
    bothEnds: 'True'
    flag: flag
  states: {}
- name: DLC_removeFlags_0
  id: DLC_removeFlags
  parameters:
    flag: flag
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '11'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: (1,0,0,1,0,1,1,0,1,0,1)
  states: {}
- name: note_0
  id: note
  parameters:
    note: As bit stuffing happens before adding the flags, we take unpacked bits as the input
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}

connections:
- [DLC_addFlags_0, out, blocks_message_debug_0, print_pdu]
- [DLC_addFlags_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [DLC_removeFlags_0, pdu_out, blocks_message_debug_0_0, print_pdu]
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', DLC_removeFlags_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, DLC_addFlags_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
