options:
  parameters:
    description: Transport layer addressing test with simulated packet loss channel
    generate_options: qt_gui
    id: test_addressing
    output_language: python
    title: Transport Layer Addressing + Packet Loss Test
  states: {}

blocks:
- name: drop_fwd
  id: variable_qtgui_range
  parameters:
    comment: Forward channel (initiator->responder) drop probability
    gui_hint: 0,0,1,1
    label: '"Fwd Drop Prob"'
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.2'
  states: {}
- name: drop_rev
  id: variable_qtgui_range
  parameters:
    comment: Reverse channel (responder->initiator) drop probability
    gui_hint: 0,1,1,1
    label: '"Rev Drop Prob"'
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.1'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '1000'
    type: complex
  states: {}
- name: channel_fwd
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt, random

      class blk(gr.basic_block):
          """Lossy PDU channel — drops each PDU with probability p_drop.
          p_drop is read live from the module-level variable so a QT Range
          slider can update it at runtime."""

          def __init__(self, p_drop=0.2):
              gr.basic_block.__init__(
                  self,
                  name='Lossy Channel',
                  in_sig=None,
                  out_sig=None
              )
              self.p_drop = p_drop
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def set_p_drop(self, p):
              self.p_drop = p

          def handle_msg(self, msg):
              if random.random() >= self.p_drop:
                  self.message_port_pub(pmt.intern('pdu_out'), msg)
              # else: packet is silently dropped
    comment: Forward lossy channel — drop_fwd slider controls loss rate
    p_drop: drop_fwd
  states: {}
- name: channel_rev
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt, random

      class blk(gr.basic_block):
          """Lossy PDU channel — drops each PDU with probability p_drop.
          p_drop is read live from the module-level variable so a QT Range
          slider can update it at runtime."""

          def __init__(self, p_drop=0.1):
              gr.basic_block.__init__(
                  self,
                  name='Lossy Channel Rev',
                  in_sig=None,
                  out_sig=None
              )
              self.p_drop = p_drop
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def set_p_drop(self, p):
              self.p_drop = p

          def handle_msg(self, msg):
              if random.random() >= self.p_drop:
                  self.message_port_pub(pmt.intern('pdu_out'), msg)
    comment: Reverse lossy channel — drop_rev slider controls loss rate
    p_drop: drop_rev
  states: {}
- name: debug_decoy
  id: blocks_message_debug
  parameters:
    comment: app_out from DECOY (addr=3) — should stay SILENT (addressing filter)
  states: {}
- name: debug_initiator
  id: blocks_message_debug
  parameters:
    comment: app_out from INITIATOR — unused in this scenario
  states: {}
- name: debug_responder
  id: blocks_message_debug
  parameters:
    comment: app_out from RESPONDER (addr=2) — should receive payload
  states: {}
- name: msg_strobe
  id: blocks_message_strobe
  parameters:
    comment: Sends to dst_addr=2 dst_port=1 every 4s
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(25, [2, 1, 1, 0, 0, 0, 0, 17] + [ord(c) for c in "Hello from Node1"]))
    period: '4000'
  states: {}
- name: transport_decoy
  id: transport_transport_layer
  parameters:
    local_addr: '3'
    local_port: '1'
    m: '4'
    mtu_bytes: '200'
    node_role: '"responder"'
    rto_ms: '600'
  states: {}
- name: transport_initiator
  id: transport_transport_layer
  parameters:
    local_addr: '1'
    local_port: '1'
    m: '4'
    mtu_bytes: '200'
    node_role: '"initiator"'
    rto_ms: '500'
  states: {}
- name: transport_responder
  id: transport_transport_layer
  parameters:
    local_addr: '2'
    local_port: '1'
    m: '4'
    mtu_bytes: '200'
    node_role: '"responder"'
    rto_ms: '500'
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [channel_fwd, pdu_out, transport_decoy, pdu_in]
- [channel_fwd, pdu_out, transport_responder, pdu_in]
- [channel_rev, pdu_out, transport_initiator, pdu_in]
- [msg_strobe, strobe, transport_initiator, app_in]
- [transport_decoy, app_out, debug_decoy, print_pdu]
- [transport_decoy, pdu_out, channel_rev, pdu_in]
- [transport_initiator, app_out, debug_initiator, print_pdu]
- [transport_initiator, pdu_out, channel_fwd, pdu_in]
- [transport_responder, app_out, debug_responder, print_pdu]
- [transport_responder, pdu_out, channel_rev, pdu_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
