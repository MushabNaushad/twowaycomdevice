options:
  parameters:
    author: MethalMindiya
    description: Multi-Node ZeroMQ Radio Transport Flowgraph for Commlink GUI Application
    generate_options: qt_gui
    id: commlink_radio
    output_language: python
    run_command: '"/home/methalabeywickrama/Documents/CDP Project/twowaycomdevice/run_radio_grc.sh" {filename}'
    title: Commlink Multi-Node Radio Transport Flowgraph (Nodes 1-5)
  states: {}

blocks:
- name: drop_prob
  id: variable_qtgui_range
  parameters:
    comment: Simulated RF Channel Packet Loss Rate
    gui_hint: 0,0,1,2
    label: '"RF Loss Rate (p_drop)"'
    min_len: '250'
    start: '0'
    step: '0.05'
    stop: '0.5'
    value: '0.0'
  states: {}
- name: m
  id: variable
  parameters:
    comment: Sequence space bit width (m=14 -> 16384 seq, Window W=8192, 16MB+ capacity)
    value: '14'
  states: {}
- name: mtu
  id: variable
  parameters:
    comment: Max transmission unit (1000B payload)
    value: '1000'
  states: {}
- name: rto_ms
  id: variable
  parameters:
    comment: Retransmission timeout (400ms)
    value: '400'
  states: {}
- name: blocks_null_snk
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_src
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: '32000'
    type: byte
  states: {}
- name: message_debug_0
  id: blocks_message_debug
  parameters:
    comment: RF Packet Monitor & Hex Dump Console
  states: {}
- name: rf_bus
  id: epy_block
  parameters:
    _source_code: |
      import pmt, random
      from gnuradio import gr

      class multi_node_rf_bus(gr.basic_block):
          def __init__(self, drop_prob=0.0):
              gr.basic_block.__init__(self, name="Shared RF Broadcast Bus", in_sig=[], out_sig=[])
              self.drop_prob = drop_prob
              for i in range(1, 6):
                  self.message_port_register_in(pmt.intern(f"pdu_in_{i}"))
                  self.message_port_register_out(pmt.intern(f"pdu_out_{i}"))
              
              self.message_port_register_out(pmt.intern("mon_out"))

              self.set_msg_handler(pmt.intern("pdu_in_1"), self.handle_1)
              self.set_msg_handler(pmt.intern("pdu_in_2"), self.handle_2)
              self.set_msg_handler(pmt.intern("pdu_in_3"), self.handle_3)
              self.set_msg_handler(pmt.intern("pdu_in_4"), self.handle_4)
              self.set_msg_handler(pmt.intern("pdu_in_5"), self.handle_5)

          def set_drop_prob(self, p):
              self.drop_prob = p

          def _route(self, msg, src_id):
              if not pmt.is_pair(msg): return
              data = pmt.cdr(msg)
              if not pmt.is_u8vector(data): return
              raw = bytes(pmt.u8vector_elements(data))
              if len(raw) < 18: return

              types = {1:'SYN', 2:'SYN_ACK', 3:'DATA', 4:'ACK', 5:'FIN', 6:'FIN_ACK'}
              pkt_type = types.get(raw[0], f'0x{raw[0]:02X}')
              src_addr = raw[2]
              dst_addr = raw[4]
              seq = (raw[6] << 8) | raw[7]
              tot = (raw[8] << 8) | raw[9]
              sid = int.from_bytes(raw[10:18], 'big')

              if random.random() < self.drop_prob:
                  print(f"  [RF AIR DROP] Node {src_id}->{dst_addr} Type={pkt_type} Seq={seq} (DROPPED)", flush=True)
                  return

              print(f"  [RF AIR BUS] Node {src_id}->Node {dst_addr} Type={pkt_type:<7} | Seq={seq}/{tot} (Length={len(raw)}B)", flush=True)
              air_pdu = pmt.cons(pmt.make_dict(), data)

              for dst_id in range(1, 6):
                  if dst_id != src_id:
                      self.message_port_pub(pmt.intern(f"pdu_out_{dst_id}"), air_pdu)

              self.message_port_pub(pmt.intern("mon_out"), air_pdu)

          def handle_1(self, msg): self._route(msg, 1)
          def handle_2(self, msg): self._route(msg, 2)
          def handle_3(self, msg): self._route(msg, 3)
          def handle_4(self, msg): self._route(msg, 4)
          def handle_5(self, msg): self._route(msg, 5)
    comment: Shared RF broadcast medium with simulated packet loss
    drop_prob: drop_prob
  states: {}
- name: transport_n1
  id: transport_transport_layer
  parameters:
    comment: Transport Layer Node 1
    local_addr: '1'
    local_port: '0'
    m: m
    mtu_bytes: mtu
    node_role: '"initiator"'
    rto_ms: rto_ms
  states: {}
- name: transport_n2
  id: transport_transport_layer
  parameters:
    comment: Transport Layer Node 2
    local_addr: '2'
    local_port: '0'
    m: m
    mtu_bytes: mtu
    node_role: '"responder"'
    rto_ms: rto_ms
  states: {}
- name: transport_n3
  id: transport_transport_layer
  parameters:
    comment: Transport Layer Node 3
    local_addr: '3'
    local_port: '0'
    m: m
    mtu_bytes: mtu
    node_role: '"responder"'
    rto_ms: rto_ms
  states: {}
- name: transport_n4
  id: transport_transport_layer
  parameters:
    comment: Transport Layer Node 4
    local_addr: '4'
    local_port: '0'
    m: m
    mtu_bytes: mtu
    node_role: '"responder"'
    rto_ms: rto_ms
  states: {}
- name: transport_n5
  id: transport_transport_layer
  parameters:
    comment: Transport Layer Node 5
    local_addr: '5'
    local_port: '0'
    m: m
    mtu_bytes: mtu
    node_role: '"responder"'
    rto_ms: rto_ms
  states: {}
- name: zmq_pull_n1
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:52001
    bind: 'True'
    comment: Node 1 App Input
    timeout: '100'
  states: {}
- name: zmq_pull_n2
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:52003
    bind: 'True'
    comment: Node 2 App Input
    timeout: '100'
  states: {}
- name: zmq_pull_n3
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:52005
    bind: 'True'
    comment: Node 3 App Input
    timeout: '100'
  states: {}
- name: zmq_pull_n4
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:52007
    bind: 'True'
    comment: Node 4 App Input
    timeout: '100'
  states: {}
- name: zmq_pull_n5
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:52009
    bind: 'True'
    comment: Node 5 App Input
    timeout: '100'
  states: {}
- name: zmq_push_n1
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:52002
    comment: Node 1 App Output
    timeout: '100'
  states: {}
- name: zmq_push_n2
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:52004
    comment: Node 2 App Output
    timeout: '100'
  states: {}
- name: zmq_push_n3
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:52006
    comment: Node 3 App Output
    timeout: '100'
  states: {}
- name: zmq_push_n4
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:52008
    comment: Node 4 App Output
    timeout: '100'
  states: {}
- name: zmq_push_n5
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:52010
    comment: Node 5 App Output
    timeout: '100'
  states: {}

connections:
- [blocks_null_src, '0', blocks_throttle, '0']
- [blocks_throttle, '0', blocks_null_snk, '0']
- [rf_bus, mon_out, message_debug_0, print_pdu]
- [rf_bus, pdu_out_1, transport_n1, pdu_in]
- [rf_bus, pdu_out_2, transport_n2, pdu_in]
- [rf_bus, pdu_out_3, transport_n3, pdu_in]
- [rf_bus, pdu_out_4, transport_n4, pdu_in]
- [rf_bus, pdu_out_5, transport_n5, pdu_in]
- [transport_n1, app_out, zmq_push_n1, in]
- [transport_n1, pdu_out, rf_bus, pdu_in_1]
- [transport_n2, app_out, zmq_push_n2, in]
- [transport_n2, pdu_out, rf_bus, pdu_in_2]
- [transport_n3, app_out, zmq_push_n3, in]
- [transport_n3, pdu_out, rf_bus, pdu_in_3]
- [transport_n4, app_out, zmq_push_n4, in]
- [transport_n4, pdu_out, rf_bus, pdu_in_4]
- [transport_n5, app_out, zmq_push_n5, in]
- [transport_n5, pdu_out, rf_bus, pdu_in_5]
- [zmq_pull_n1, out, transport_n1, app_in]
- [zmq_pull_n2, out, transport_n2, app_in]
- [zmq_pull_n3, out, transport_n3, app_in]
- [zmq_pull_n4, out, transport_n4, app_in]
- [zmq_pull_n5, out, transport_n5, app_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
