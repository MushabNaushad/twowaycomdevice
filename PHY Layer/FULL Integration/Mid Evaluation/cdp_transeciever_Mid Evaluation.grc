options:
  parameters:
    author: mushab404
    generate_options: qt_gui
    id: transeciever
    output_language: python
    title: 'CDP transeciever '
  states: {}

blocks:
- name: ADDR
  id: variable
  parameters:
    value: '"ip:192.168.1.10"'
  states: {}
- name: BPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[1+0j, -1+0j]'
    imag_sect: '1'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: CH_GAIN
  id: variable
  parameters:
    value: '20.0'
  states: {}
- name: QPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: SDR_CF
  id: variable
  parameters:
    value: '410000000.0'
  states: {}
- name: adpt_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: QPSK_CONST
    modulus: '1'
    step_size: '.005'
    type: cma
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.45'
  states: {}
- name: amble
  id: variable
  parameters:
    value: '[0xc0, 0xaf]'
  states: {}
- name: amble
  id: variable
  parameters:
    value: '[0xc0, 0xaf]'
  states: {state: disabled}
- name: costas_bw
  id: variable
  parameters:
    value: '0.15'
  states: {}
- name: fll_loop_bw
  id: variable
  parameters:
    value: '0.0314'
  states: {}
- name: frequency_offset
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Frequency offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0.005'
  states: {state: disabled}
- name: hdr
  id: variable
  parameters:
    comment: |-
      digital.header_format_default(
          digital.packet_utils.default_access_code, 0)
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: 'Channel : Noise Voltage'
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.1'
  states: {state: disabled}
- name: packets
  id: variable
  parameters:
    value: '50'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.1415926'
  states: {}
- name: postamble_size
  id: variable
  parameters:
    value: '8'
  states: {}
- name: preamble_size
  id: variable
  parameters:
    value: '32'
  states: {}
- name: preamble_symbols
  id: variable
  parameters:
    value: '[1+1j, -1-1j, -1-1j, -1-1j, 1-1j, 1-1j, 1+1j, 1+1j]'
  states: {}
- name: rcc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: alpha
    gain: '1'
    ntaps: nfilts*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/float(sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sym_bw
  id: variable
  parameters:
    value: '0.0250'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Time Offset'
    start: '0.999'
    step: '0.000001'
    stop: '1.001'
    value: '1.00001'
  states: {state: disabled}
- name: training_seq
  id: variable
  parameters:
    value: '[1+1j, -1-1j, -1-1j, -1-1j, 1-1j, 1-1j, 1+1j, 1+1j]'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-2'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {}
- name: blocks_copy_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_1_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      used to skip head until 
      the filter settles.
    num_items: int(samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 1, 2, 3, 0, 1, 2, 3)
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_volt
    seed: '0'
    taps: '1.0'
  states: {state: disabled}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK_CONST
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: BPSK_CONST
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: BPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: BPSK_CONST.arity()
    w: costas_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: 2* sps +1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: fll_loop_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: adpt_alg
    num_taps: '11'
    sps: '1'
    training_sequence: '[]'
    training_start_tag: '""'
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: sym_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import zlib
      import time
      import random
      import threading
      import queue

      class MacCsmaFramerTX(gr.basic_block):
          """
          Implements MAC framing, CSMA/CA (LBT + SIFS + Exponential Backoff),
          and frame construction [Dest (1B) | Src (1B) | Len (2B) | Payload | CRC32 (4B)].
          """
          def __init__(self, src_id=1, default_dest_id=0xFF, sifs_gap=0.015, base_backoff=0.02, max_attempts=10):
              gr.basic_block.__init__(
                  self,
                  name="MAC CSMA Framer TX",
                  in_sig=None,
                  out_sig=None
              )
              self.src_id = int(src_id) & 0xFF
              self.default_dest_id = int(default_dest_id) & 0xFF
              self.sifs_gap = float(sifs_gap)
              self.base_backoff = float(base_backoff)
              self.max_attempts = int(max_attempts)

              # Channel state tracking
              self.channel_state = "IDLE"  # "IDLE", "RECEIVING", "TRANSMITTING"
              self.last_rx_endtime = 0.0
              self.state_lock = threading.Lock()

              # Message Ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_app_msg)

              self.message_port_register_in(pmt.intern("rx_status_in"))
              self.set_msg_handler(pmt.intern("rx_status_in"), self.handle_rx_status)

              self.message_port_register_out(pmt.intern("pdu_out"))

              # Asynchronous TX worker queue
              self.tx_queue = queue.Queue()
              self.running = True
              self.worker_thread = threading.Thread(target=self._tx_worker, daemon=True)
              self.worker_thread.start()

          def set_src_id(self, src_id):
              self.src_id = int(src_id) & 0xFF

          def set_default_dest_id(self, default_dest_id):
              self.default_dest_id = int(default_dest_id) & 0xFF

          def set_channel_state(self, new_state):
              with self.state_lock:
                  if self.channel_state == "RECEIVING" and new_state == "IDLE":
                      self.last_rx_endtime = time.time()
                  self.channel_state = new_state

          def is_channel_free(self):
              with self.state_lock:
                  if self.channel_state != "IDLE":
                      return False
                  if (time.time() - self.last_rx_endtime) < self.sifs_gap:
                      return False
                  return True

          def handle_rx_status(self, msg):
              status_str = str(pmt.to_python(msg)).upper()
              if "START" in status_str or "BUSY" in status_str or "RECV" in status_str:
                  self.set_channel_state("RECEIVING")
              elif "END" in status_str or "IDLE" in status_str:
                  self.set_channel_state("IDLE")

          def handle_app_msg(self, msg):
              dest_id = self.default_dest_id
              payload = b""

              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = pmt.cdr(msg)
                  if pmt.is_dict(meta):
                      d_val = pmt.dict_ref(meta, pmt.intern("dest_id"), pmt.PMT_NIL)
                      if not pmt.is_null(d_val):
                          dest_id = pmt.to_long(d_val) & 0xFF
                  if pmt.is_u8vector(data):
                      payload = bytes(pmt.u8vector_elements(data))
                  elif pmt.is_uniform_vector(data):
                      payload = bytes(pmt.to_python(data))
              elif pmt.is_symbol(msg) or pmt.is_string(msg):
                  payload = pmt.to_python(msg).encode('utf-8')
              else:
                  py_val = pmt.to_python(msg)
                  if isinstance(py_val, tuple) and len(py_val) == 2 and isinstance(py_val[0], int):
                      dest_id = py_val[0] & 0xFF
                      payload = py_val[1].encode('utf-8') if isinstance(py_val[1], str) else bytes(py_val[1])
                  elif isinstance(py_val, str):
                      payload = py_val.encode('utf-8')
                  elif isinstance(py_val, (bytes, bytearray)):
                      payload = bytes(py_val)

              if not payload:
                  return

              # Frame: [Dest ID (1B) | Src ID (1B) | Length (2B) | Payload | CRC32 (4B)]
              len_hdr = len(payload).to_bytes(2, byteorder='big')
              crc_hdr = zlib.crc32(payload).to_bytes(4, byteorder='big')
              mac_frame = bytes([dest_id, self.src_id]) + len_hdr + payload + crc_hdr

              vec = pmt.init_u8vector(len(mac_frame), list(mac_frame))
              pdu = pmt.cons(pmt.PMT_NIL, vec)
              self.tx_queue.put(pdu)

          def _tx_worker(self):
              while self.running:
                  try:
                      pdu = self.tx_queue.get(timeout=0.05)
                  except queue.Empty:
                      continue

                  # CSMA / LBT Contention Loop
                  sent = False
                  for attempt in range(self.max_attempts):
                      if self.is_channel_free():
                          self.set_channel_state("TRANSMITTING")
                          self.message_port_pub(pmt.intern("pdu_out"), pdu)
                          time.sleep(0.010)  # Airtime / burst clearance window
                          self.set_channel_state("IDLE")
                          sent = True
                          break

                      # Exponential backoff on channel busy
                      cw_max = min(16, 2 ** attempt)
                      random_slots = random.randint(1, cw_max)
                      time.sleep(random_slots * self.base_backoff)

                  if not sent:
                      print(f"[MAC CSMA] Dropped frame: Channel busy after {self.max_attempts} attempts", flush=True)

                  self.tx_queue.task_done()

          def stop(self):
              self.running = False
              if self.worker_thread.is_alive():
                  self.worker_thread.join(timeout=0.2)
              return gr.basic_block.stop(self)
    base_backoff: ''
    default_dest_id: '255'
    max_attempts: ''
    sifs_gap: ''
    src_id: '1'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt

      class PacketFramerTX(gr.basic_block):
          def __init__(self, preamble_len=64, postamble_len=16, repeat_count=3):
              gr.basic_block.__init__(
                  self,
                  name="Packet Framer TX (PHY)",
                  in_sig=None,
                  out_sig=None
              )
              self.preamble_len = int(preamble_len)
              self.postamble_len = int(postamble_len)
              self.repeat_count = int(repeat_count)
              self.sync_word = bytes([0x1A, 0xCF, 0xFC, 0x1D])

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.message_port_register_out(pmt.intern("pdu_out"))

          def set_repeat_count(self, repeat_count):
              self.repeat_count = int(repeat_count)

          def handle_pdu(self, msg):
              if not pmt.is_pair(msg):
                  return
              data = pmt.cdr(msg)
              if not pmt.is_u8vector(data):
                  return

              mac_payload = bytes(pmt.u8vector_elements(data))
              if not mac_payload:
                  return

              # PHY Frame: Preamble + Sync Word + MAC Frame + Postamble
              preamble = bytes([0xAA] * self.preamble_len)
              postamble = bytes([0xAA] * self.postamble_len)
              phy_frame = preamble + self.sync_word + mac_payload + postamble

              vec = pmt.init_u8vector(len(phy_frame), list(phy_frame))
              pdu = pmt.cons(pmt.PMT_NIL, vec)

              for _ in range(self.repeat_count):
                  self.message_port_pub(pmt.intern("pdu_out"), pdu)
    postamble_len: '16'
    preamble_len: '16'
    repeat_count: '5'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt

      class PacketDeframerRX(gr.sync_block):
          """
          PHY Deframer: Bit sync, frame extraction, and carrier sensing status reporter.
          """
          STATE_SYNC = 0
          STATE_MAC_HDR = 1
          STATE_PAYLOAD_CRC = 2

          def __init__(self, max_bit_errors=1, max_payload_len=512):
              gr.sync_block.__init__(
                  self,
                  name="Packet Deframer RX (PHY)",
                  in_sig=[np.uint8],
                  out_sig=None
              )
              self.max_bit_errors = int(max_bit_errors)
              self.max_payload_len = int(max_payload_len)
              self.sync_target = 0x1ACFFC1D

              self.state = self.STATE_SYNC
              self.shift_reg = 0
              self.bit_buf = 0
              self.bit_count = 0
              self.byte_buf = bytearray()
              self.payload_len = 0
              self.target_bytes = 0

              self.message_port_register_out(pmt.intern("pdu_out"))
              self.message_port_register_out(pmt.intern("status_out"))

          def work(self, input_items, output_items):
              in_bits = input_items[0]

              for bit in in_bits:
                  b = int(bit) & 1

                  if self.state == self.STATE_SYNC:
                      self.shift_reg = ((self.shift_reg << 1) | b) & 0xFFFFFFFF
                      xor_diff = self.shift_reg ^ self.sync_target

                      if bin(xor_diff).count('1') <= self.max_bit_errors:
                          # Sync detected: Notify CSMA MAC that channel is busy
                          self.message_port_pub(pmt.intern("status_out"), pmt.intern("RX_START"))
                          self.state = self.STATE_MAC_HDR
                          self.bit_buf = 0
                          self.bit_count = 0
                          self.byte_buf = bytearray()
                          self.target_bytes = 4  # [Dest ID (1B), Src ID (1B), Length (2B)]

                  elif self.state == self.STATE_MAC_HDR:
                      self.bit_buf = (self.bit_buf << 1) | b
                      self.bit_count += 1
                      if self.bit_count == 8:
                          self.byte_buf.append(self.bit_buf)
                          self.bit_buf = 0
                          self.bit_count = 0
                          if len(self.byte_buf) == self.target_bytes:
                              self.payload_len = (self.byte_buf[2] << 8) | self.byte_buf[3]
                              if 0 < self.payload_len <= self.max_payload_len:
                                  self.state = self.STATE_PAYLOAD_CRC
                                  self.target_bytes = 4 + self.payload_len + 4  # Hdr(4) + Payload + CRC(4)
                              else:
                                  # Invalid length / False trigger: Reset channel state
                                  self.message_port_pub(pmt.intern("status_out"), pmt.intern("RX_END"))
                                  self.state = self.STATE_SYNC

                  elif self.state == self.STATE_PAYLOAD_CRC:
                      self.bit_buf = (self.bit_buf << 1) | b
                      self.bit_count += 1
                      if self.bit_count == 8:
                          self.byte_buf.append(self.bit_buf)
                          self.bit_buf = 0
                          self.bit_count = 0
                          if len(self.byte_buf) == self.target_bytes:
                              pdu_vec = pmt.init_u8vector(len(self.byte_buf), list(self.byte_buf))
                              self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(pmt.PMT_NIL, pdu_vec))
                              self.message_port_pub(pmt.intern("status_out"), pmt.intern("RX_END"))

                              self.state = self.STATE_SYNC
                              self.shift_reg = 0

              return len(in_bits)
    max_bit_errors: '1'
    max_payload_len: '4096'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import zlib

      class MacDeframerRX(gr.basic_block):
          def __init__(self, my_node_id=2):
              gr.basic_block.__init__(
                  self,
                  name="MAC Deframer RX",
                  in_sig=None,
                  out_sig=None
              )
              self.my_node_id = int(my_node_id) & 0xFF

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.message_port_register_out(pmt.intern("pdu_out"))

          def set_my_node_id(self, my_node_id):
              self.my_node_id = int(my_node_id) & 0xFF

          def handle_pdu(self, msg):
              if not pmt.is_pair(msg):
                  return
              data = pmt.cdr(msg)
              if not pmt.is_u8vector(data):
                  return

              raw_bytes = bytes(pmt.u8vector_elements(data))
              if len(raw_bytes) < 9:
                  return

              dest_id = raw_bytes[0]
              src_id = raw_bytes[1]
              payload_len = (raw_bytes[2] << 8) | raw_bytes[3]

              if len(raw_bytes) != (8 + payload_len):
                  return

              payload = raw_bytes[4:4 + payload_len]
              rx_crc = int.from_bytes(raw_bytes[4 + payload_len: 8 + payload_len], 'big')
              calc_crc = zlib.crc32(payload)

              # 1. Check CRC
              if rx_crc != calc_crc:
                  print(f"[MAC CRC ERROR] Dest: {dest_id:#04x}, Src: {src_id:#04x} | Expected: {calc_crc:#010x}, Received: {rx_crc:#010x}", flush=True)
                  return

              # 2. Match Node Address or Broadcast (0xFF)
              if dest_id == self.my_node_id or dest_id == 0xFF:
                  msg_str = payload.decode('utf-8', errors='replace')
                  print(f"\n========================================", flush=True)
                  print(f"[MAC RX] Node {src_id} -> Node {dest_id} ({payload_len} Bytes): {msg_str}", flush=True)
                  print(f"========================================\n", flush=True)

                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("src_id"), pmt.from_long(src_id))
                  meta = pmt.dict_add(meta, pmt.intern("dest_id"), pmt.from_long(dest_id))
                  out_vec = pmt.init_u8vector(len(payload), list(payload))
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, out_vec))
    my_node_id: ''
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: rcc_taps
    type: ccc
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: CH_GAIN
    bandwidth: '20000000'
    buffer_size: '4096'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(SDR_CF)
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '4096'
    filter_source: '''Auto'''
    frequency: int(SDR_CF)
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: '"TX Message"'
    type: string
    value: '"MESSAGE"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '2048'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/float(sps)
    type: fir_filter_ccf
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: SDR_CF
    dev_args: '"driver=bladerf"'
    gain: CH_GAIN
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: SDR_CF
    dev_args: '"driver=bladerf"'
    gain: CH_GAIN
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    bufflen: '4096'
    center_freq: SDR_CF
    gain: CH_GAIN
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: sent_bytes
  states: {state: disabled}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx
  states: {state: disabled}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {state: disabled}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: decoded_constallation
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: time
  states: {state: disabled}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: freq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: tx
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: tx
  states: {state: disabled}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: rx
  states: {state: disabled}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: decoded_constallation
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: decoded_stream
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: time
  states: {state: disabled}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: freq
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_copy_1, '0']
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_random_source_x_0, '0', blocks_copy_0, '0']
- [analog_random_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_0_0, '0']
- [blocks_char_to_float_0, '0', virtual_sink_4, '0']
- [blocks_char_to_float_0, '0', virtual_sink_5, '0']
- [blocks_copy_0, '0', digital_constellation_modulator_0, '0']
- [blocks_copy_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_copy_1, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_1_0, '0', blocks_copy_1, '0']
- [blocks_copy_1_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_copy_1_1, '0', analog_agc_xx_0, '0']
- [blocks_copy_1_1, '0', blocks_copy_1_0, '0']
- [blocks_copy_1_2, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_2, '0', digital_costas_loop_cc_0, '0']
- [blocks_skiphead_0, '0', fft_filter_xxx_0, '0']
- [blocks_skiphead_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_tag_gate_0, '0', iio_pluto_sink_0, '0']
- [blocks_tag_gate_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_tag_gate_0, '0', virtual_sink_0, '0']
- [blocks_tag_gate_0, '0', virtual_sink_5, '0']
- [blocks_throttle2_0, '0', digital_constellation_modulator_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_2, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', virtual_sink_2_0, '0']
- [blocks_vector_source_x_0, '0', blocks_copy_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_vector_source_x_0, '0', virtual_sink_0_0, '0']
- [channels_channel_model_0, '0', virtual_sink_1, '0']
- [dc_blocker_xx_0, '0', analog_agc_xx_0, '0']
- [dc_blocker_xx_0, '0', blocks_copy_1_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_tag_gate_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_tag_gate_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_copy_1_2, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_copy_2, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_0, pdu_out, epy_block_0_0, pdu_in]
- [epy_block_0_0, pdu_out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [epy_block_0_0_0, pdu_out, epy_block_1, pdu_in]
- [epy_block_0_0_0, status_out, epy_block_0, rx_status_in]
- [epy_block_1, pdu_out, blocks_message_debug_0, print_pdu]
- [fft_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [iio_pluto_source_0, '0', blocks_copy_1_1, '0']
- [iio_pluto_source_0, '0', dc_blocker_xx_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', virtual_sink_0_1, '0']
- [qtgui_edit_box_msg_0_0, msg, epy_block_0, msg_in]
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_bladerf_source_0, '0', blocks_copy_1_1, '0']
- [soapy_bladerf_source_0, '0', dc_blocker_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_copy_1_1, '0']
- [virtual_source_0_0, '0', blocks_copy_0, '0']
- [virtual_source_0_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0_0_0, '0', blocks_copy_1_1, '0']
- [virtual_source_0_0_0, '0', dc_blocker_xx_0, '0']
- [virtual_source_1, '0', channels_channel_model_0, '0']
- [virtual_source_1_0, '0', blocks_copy_1_1, '0']
- [virtual_source_1_0, '0', dc_blocker_xx_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0_0, '0']
- [virtual_source_2, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_2_0, '0', epy_block_0_0_0, '0']
- [virtual_source_3, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_4, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
