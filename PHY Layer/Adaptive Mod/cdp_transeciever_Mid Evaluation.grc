options:
  parameters:
    author: mushab404
    generate_options: qt_gui
    id: transeciever
    output_language: python
    title: 'CDP transeciever '
  states: {}

blocks:
- name: ADDR
  id: variable
  parameters:
    value: '"ip:192.168.1.10"'
  states: {}
- name: BPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[-1+0j, 1+0j]'
    imag_sect: '1'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: CH_GAIN
  id: variable
  parameters:
    value: '20.0'
  states: {}
- name: QPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: SDR_CF
  id: variable
  parameters:
    value: '410000000.0'
  states: {}
- name: adpt_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: QPSK_CONST
    modulus: '1'
    step_size: '.1'
    type: cma
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: costas_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: ep
  id: variable_qtgui_range
  parameters:
    start: '0.9999'
    step: '0.0001'
    stop: '1.0001'
    value: '1'
  states: {}
- name: fll_loop_bw
  id: variable
  parameters:
    value: '0.0314'
  states: {}
- name: fo
  id: variable_qtgui_range
  parameters:
    start: '-0.01'
    step: '0.001'
    stop: '0.01'
    value: '0'
  states: {}
- name: nv
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sym_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-2'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: '0'
    showports: 'False'
    type: byte
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: byte
  states: {}
- name: blocks_selector_0_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: blocks_unpack_k_bits_bb_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: ep
    freq_offset: fo
    noise_voltage: nv
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1+0j, 1+0j]'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1+0j, 1+0j]'
  states: {}
- name: digital_chunks_to_symbols_xx_0_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[(-1-1j)/1.414, (-1+1j)/1.414, (1+1j)/1.414, (1-1j)/1.414]'
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: BPSK_CONST
  states: {}
- name: digital_constellation_decoder_cb_0_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: BPSK_CONST
  states: {}
- name: digital_constellation_decoder_cb_0_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK_CONST
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '0'
    sps: '1'
    symbols: '[-1.0 if b == ''0'' else 1.0 for b in f"{0x1ACFFC1D:032b}"]'
    threshold: '0.75'
    threshold_method: digital.THRESHOLD_DYNAMIC
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: QPSK_CONST.arity()
    w: costas_bw
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: BPSK_CONST.arity()
    w: costas_bw
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: BPSK_CONST.arity()
    w: costas_bw
  states: {}
- name: digital_diff_decoder_bb_0_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_diff_decoder_bb_0_0_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_diff_decoder_bb_0_1
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_diff_encoder_bb_0_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_diff_encoder_bb_0_1
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: 2* sps +1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: fll_loop_bw
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: '33'
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"payload_symbols"'
    output_symbols: 'False'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '"rx_time"'
    trigger_tag_key: '"time_est"'
    type: complex
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: adpt_alg
    num_taps: '15'
    sps: '1'
    training_sequence: '[]'
    training_start_tag: '""'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 2, 3]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: sym_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class HeaderRecoveryBlock(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="Header Recovery & MCS Decoder",
                  in_sig=[np.uint8],
                  out_sig=[]
              )
              self.message_port_register_out(pmt.intern("len_out"))
              self.message_port_register_out(pmt.intern("mcs_out"))
              self.message_port_register_out(pmt.intern("header_data"))
              self.bit_buf = []

          def work(self, input_items, output_items):
              in_bits = input_items[0]
              for b in in_bits:
                  self.bit_buf.append(int(b) & 1)

                  # 33 bits: 1 trailing sync bit + 32 metadata bits
                  if len(self.bit_buf) == 33:
                      # Discard index 0 (the boundary sync bit)
                      meta_bits = self.bit_buf[1:]
                      
                      raw_bytes = bytearray()
                      for i in range(0, 32, 8):
                          byte_val = 0
                          for j in range(8):
                              byte_val = (byte_val << 1) | meta_bits[i + j]
                          raw_bytes.append(byte_val)

                      b0, b1, b2, b3 = raw_bytes[0], raw_bytes[1], raw_bytes[2], raw_bytes[3]
                      valid = False

                      # Case 1: Normal phase
                      if ((b0 + b1 + b2) & 0xFF) == b3:
                          valid = True
                      # Case 2: Inverted 180 deg phase
                      elif (((~b0 & 0xFF) + (~b1 & 0xFF) + (~b2 & 0xFF)) & 0xFF) == (~b3 & 0xFF):
                          b0, b1, b2 = (~b0) & 0xFF, (~b1) & 0xFF, (~b2) & 0xFF
                          valid = True

                      if valid:
                          selected_mcs = 1 if b0 == 1 else 0
                          payload_len = (b1 << 8) | b2
                          syms = (payload_len * 8) if selected_mcs == 0 else (payload_len * 4)

                          print(f"[RX] Header Valid! MCS={selected_mcs} ({'QPSK' if selected_mcs==1 else 'BPSK'}), Payload={payload_len} bytes ({syms} syms)", flush=True)

                          demux_info = pmt.make_dict()
                          demux_info = pmt.dict_add(demux_info, pmt.intern("payload_symbols"), pmt.from_long(syms))

                          self.message_port_pub(pmt.intern("header_data"), demux_info)
                          self.message_port_pub(pmt.intern("len_out"), pmt.from_long(payload_len))
                          self.message_port_pub(
                              pmt.intern("mcs_out"),
                              pmt.cons(pmt.PMT_NIL, pmt.from_long(selected_mcs))
                          )
                      else:
                          print(f"[RX] Header Checksum Failed (Raw: {list(raw_bytes)})", flush=True)

                      self.bit_buf.clear()

              return len(in_bits)
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import struct
      import zlib

      class AdaptivePayloadGenerator(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="Adaptive Payload Generator",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("payload_out"))
              self.message_port_register_out(pmt.intern("len_out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              raw_bytes = b""
              if pmt.is_symbol(msg):
                  raw_bytes = pmt.symbol_to_string(msg).encode('utf-8')
              elif pmt.is_string(msg):
                  raw_bytes = pmt.to_python(msg).encode('utf-8')
              elif pmt.is_pair(msg):
                  cdr = pmt.cdr(msg)
                  if pmt.is_u8vector(cdr):
                      raw_bytes = bytes(pmt.u8vector_elements(cdr))
                  elif pmt.is_string(cdr) or pmt.is_symbol(cdr):
                      raw_bytes = pmt.to_python(cdr).encode('utf-8')
              else:
                  return

              if len(raw_bytes) == 0:
                  return

              # Append CRC32 (4 bytes, big-endian)
              crc = zlib.crc32(raw_bytes) & 0xFFFFFFFF
              framed_payload = raw_bytes + struct.pack("!I", crc)
              total_len = len(framed_payload)

              print(f"\n[TX] Transmitting: '{raw_bytes.decode('utf-8', errors='replace')}' ({total_len} bytes framed)", flush=True)

              out_vec = pmt.init_u8vector(total_len, list(framed_payload))
              self.message_port_pub(pmt.intern("payload_out"), pmt.cons(pmt.PMT_NIL, out_vec))
              self.message_port_pub(pmt.intern("len_out"), pmt.from_long(total_len))
  states: {}
- name: epy_block_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import struct

      class AdaptiveHeaderGenerator(gr.basic_block):
          def __init__(self, default_mcs=0):
              gr.basic_block.__init__(
                  self,
                  name="Adaptive Header Generator",
                  in_sig=[],
                  out_sig=[]
              )
              self.current_mcs = 1 if default_mcs == 1 else 0

              self.message_port_register_in(pmt.intern("len_in"))
              self.message_port_register_in(pmt.intern("mcs_in"))
              self.message_port_register_out(pmt.intern("header_out"))
              self.message_port_register_out(pmt.intern("mcs_out"))

              self.set_msg_handler(pmt.intern("len_in"), self.handle_len)
              self.set_msg_handler(pmt.intern("mcs_in"), self.handle_mcs)

          def handle_mcs(self, msg):
              val = None
              if pmt.is_integer(msg):
                  val = pmt.to_long(msg)
              elif pmt.is_pair(msg):
                  cdr = pmt.cdr(msg)
                  if pmt.is_integer(cdr):
                      val = pmt.to_long(cdr)
              elif pmt.is_symbol(msg) or pmt.is_string(msg):
                  s = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else pmt.symbol_name(msg)
                  val = 1 if s.upper() == "QPSK" else 0

              if val is not None:
                  self.current_mcs = 1 if val == 1 else 0

          def handle_len(self, msg):
              total_len = 0
              if pmt.is_integer(msg):
                  total_len = pmt.to_long(msg)
              elif pmt.is_pair(msg):
                  total_len = pmt.length(pmt.cdr(msg))
              else:
                  return

              mcs_byte = struct.pack("!B", self.current_mcs)
              len_bytes = struct.pack("!H", total_len)
              chk = (self.current_mcs + (total_len >> 8) + (total_len & 0xFF)) & 0xFF
              chk_byte = struct.pack("!B", chk)

              # 4 bytes metadata = 32 bits
              metadata_frame = mcs_byte + len_bytes + chk_byte

              out_vec = pmt.init_u8vector(len(metadata_frame), list(metadata_frame))
              self.message_port_pub(pmt.intern("header_out"), pmt.cons(pmt.PMT_NIL, out_vec))
              self.message_port_pub(
                  pmt.intern("mcs_out"),
                  pmt.cons(pmt.PMT_NIL, pmt.from_long(self.current_mcs))
              )
    default_mcs: '0'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class ChannelEstimatorSNR(gr.sync_block):
          """
          Estimates SNR from complex symbols and outputs recommended MCS (0 or 1).
          Uses a dual-threshold hysteresis to avoid ping-ponging.
          """
          def __init__(self, snr_low_thresh_db=7.0, snr_high_thresh_db=10.0, avg_samples=2000):
              gr.sync_block.__init__(
                  self,
                  name="Channel Estimator & MCS Decision",
                  in_sig=[np.complex64],
                  out_sig=[]
              )
              self.low_thresh = float(snr_low_thresh_db)
              self.high_thresh = float(snr_high_thresh_db)
              self.avg_samples = int(avg_samples)

              self.current_mcs = 0  # Default BPSK
              self.symbol_buf = []

              self.message_port_register_out(pmt.intern("tx_mcs_feedback"))

          def work(self, input_items, output_items):
              symbols = input_items[0]
              self.symbol_buf.extend(symbols)

              while len(self.symbol_buf) >= self.avg_samples:
                  chunk = np.array(self.symbol_buf[:self.avg_samples], dtype=np.complex64)
                  self.symbol_buf = self.symbol_buf[self.avg_samples:]

                  # Normalize signal power
                  sig_power = np.mean(np.abs(chunk)**2)
                  if sig_power < 1e-6:
                      continue

                  # Hard-decision slicing on BPSK/QPSK coordinates (+-1, +-1j)
                  ref_i = np.sign(chunk.real)
                  ref_q = np.sign(chunk.imag)
                  ref_symbols = (ref_i + 1j * ref_q) / np.sqrt(2)

                  # Error Vector Magnitude (EVM) noise estimate
                  error = chunk - ref_symbols
                  noise_power = np.mean(np.abs(error)**2)

                  if noise_power > 0:
                      snr_linear = sig_power / noise_power
                      snr_db = 10.0 * np.log10(max(snr_linear, 1e-3))
                  else:
                      snr_db = 30.0

                  # Hysteresis switching logic
                  new_mcs = self.current_mcs
                  if self.current_mcs == 0 and snr_db > self.high_thresh:
                      new_mcs = 1  # Upgrade to QPSK
                  elif self.current_mcs == 1 and snr_db < self.low_thresh:
                      new_mcs = 0  # Downgrade to BPSK

                  if new_mcs != self.current_mcs:
                      self.current_mcs = new_mcs
                      self.message_port_pub(pmt.intern("tx_mcs_feedback"), pmt.from_long(self.current_mcs))

              return len(symbols)
    avg_samples: '2000'
    snr_high_thresh_db: '10'
    snr_low_thresh_db: '7'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import struct
      import zlib

      class UnpackedPayloadDecoderSink(gr.sync_block):
          """
          Collects unpacked payload bits, drops idle noise, validates CRC32,
          and prints decoded messages to stdout.
          """
          def __init__(self, length_tag_key="packet_len"):
              gr.sync_block.__init__(
                  self,
                  name="Unpacked Payload Decoder & CRC Sink",
                  in_sig=[np.uint8],
                  out_sig=[]
              )
              self.bit_buf = []
              self.expected_payload_bytes = 0

              self.message_port_register_in(pmt.intern("len_in"))
              self.set_msg_handler(pmt.intern("len_in"), self.handle_len)

          def handle_len(self, msg):
              val = 0
              if pmt.is_integer(msg):
                  val = pmt.to_long(msg)
              elif pmt.is_pair(msg):
                  cdr = pmt.cdr(msg)
                  if pmt.is_integer(cdr):
                      val = pmt.to_long(cdr)

              if val > 0:
                  self.expected_payload_bytes = val
                  self.bit_buf.clear()  # Flush any residual noise bits

          def process_packet(self, raw_bytes):
              if len(raw_bytes) < 4:
                  return

              payload = bytes(raw_bytes[:-4])
              rx_crc = struct.unpack("!I", bytes(raw_bytes[-4:]))[0]
              calc_crc = zlib.crc32(payload) & 0xFFFFFFFF

              if rx_crc == calc_crc:
                  try:
                      text_msg = payload.decode("utf-8")
                      print("\n==================== [PAYLOAD RECEIVED] ====================")
                      print(f"Status       : CRC VALID (0x{rx_crc:08X})")
                      print(f"Payload Size : {len(payload)} bytes")
                      print(f"Message (str): {text_msg}")
                      print("============================================================\n", flush=True)
                  except UnicodeDecodeError:
                      print(f"\n[RX PAYLOAD] Binary Data ({len(payload)} bytes), CRC OK (0x{rx_crc:08X})\n", flush=True)
              else:
                  print(f"\n[RX PAYLOAD] CRC MISMATCH! Calc: 0x{calc_crc:08X}, Rx: 0x{rx_crc:08X}\n", flush=True)

          def work(self, input_items, output_items):
              in_bits = input_items[0]

              # Drop idle channel noise if no packet length has been set
              if self.expected_payload_bytes == 0:
                  return len(in_bits)

              needed_bits = self.expected_payload_bytes * 8
              for b in in_bits:
                  self.bit_buf.append(int(b) & 0x01)
                  if len(self.bit_buf) == needed_bits:
                      packed = bytearray()
                      for i in range(0, needed_bits, 8):
                          byte_val = 0
                          for j in range(8):
                              byte_val = (byte_val << 1) | self.bit_buf[i + j]
                          packed.append(byte_val)

                      self.process_packet(packed)
                      self.expected_payload_bytes = 0
                      self.bit_buf.clear()
                      break

              return len(in_bits)
    length_tag_key: '"packet_len"'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class SyncWordInserter(gr.basic_block):
          """
          Prepends raw (unencoded) Preamble and CCSDS Sync Word (0x1ACFFC1D)
          AFTER differential encoding.
          """
          def __init__(self, preamble_bytes=4):
              gr.basic_block.__init__(
                  self,
                  name="Sync Word Inserter (Post-Diff)",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.preamble_bytes = max(1, int(preamble_bytes))
              self.sync_word = 0x1ACFFC1D
              
              # Prevent double packet_len tag propagation
              self.set_tag_propagation_policy(gr.TPP_DONT)

              # 1. Build unencoded preamble bits (0xAA -> 10101010)
              preamble_bits = []
              for _ in range(self.preamble_bytes):
                  for i in range(7, -1, -1):
                      preamble_bits.append((0xAA >> i) & 1)

              # 2. Build unencoded 32-bit sync word bits
              sync_bits = [(self.sync_word >> i) & 1 for i in range(31, -1, -1)]

              self.prefix_bits = np.array(preamble_bits + sync_bits, dtype=np.uint8)
              self.prefix_len = len(self.prefix_bits)

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              nin = len(in0)

              if nin == 0:
                  return 0

              tags = self.get_tags_in_window(0, 0, nin)
              tag_offset = None
              tag_val = None
              for tag in tags:
                  if pmt.to_python(tag.key) == "packet_len":
                      tag_offset = tag.offset - self.nitems_read(0)
                      tag_val = pmt.to_python(tag.value)
                      break

              if tag_offset is not None and tag_offset == 0:
                  total_out = self.prefix_len + nin
                  if len(out) < total_out:
                      return 0

                  out[:self.prefix_len] = self.prefix_bits
                  out[self.prefix_len:total_out] = in0

                  new_tag_val = tag_val + self.prefix_len
                  self.add_item_tag(0, self.nitems_written(0), pmt.intern("packet_len"), pmt.from_long(new_tag_val))

                  self.consume(0, nin)
                  return total_out
              else:
                  n_copy = min(len(out), nin)
                  out[:n_copy] = in0[:n_copy]
                  self.consume(0, n_copy)
                  return n_copy
    preamble_bytes: '4'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: CH_GAIN
    bandwidth: '20000000'
    buffer_size: '4096'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(SDR_CF)
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '4096'
    filter_source: '''Auto'''
    frequency: int(SDR_CF)
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {state: disabled}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: firdes.root_raised_cosine(sps, samp_rate, samp_rate/sps, alpha, 11*sps)
    type: ccc
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: '"TX Message"'
    type: string
    value: '"MESSAGE"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/float(sps)
    type: fir_filter_ccf
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    bufflen: '4096'
    center_freq: SDR_CF
    gain: CH_GAIN
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: feedback
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: TX
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: RX
  states: {}
- name: virtual_sink_2_1
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: PreDemod
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: PreDemod
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: feedback
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: decoded_stream
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: RX
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: TX
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_diff_encoder_bb_0_0, '0']
- [blocks_repack_bits_bb_0_1, '0', digital_diff_encoder_bb_0_1, '0']
- [blocks_selector_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_selector_0, '1', blocks_repack_bits_bb_0_1, '0']
- [blocks_selector_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_selector_0_0_0, '0', virtual_sink_2_1, '0']
- [blocks_selector_0_1, '0', digital_costas_loop_cc_0_0_0, '0']
- [blocks_selector_0_1, '1', digital_costas_loop_cc_0, '0']
- [blocks_tagged_stream_mux_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', epy_block_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_0, '0', blocks_selector_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_1, '0', blocks_selector_0_0_0, '1']
- [channels_channel_model_0, '0', virtual_sink_2, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_selector_0_0, '0']
- [digital_chunks_to_symbols_xx_0_1, '0', blocks_selector_0_0, '1']
- [digital_constellation_decoder_cb_0_0_0, '0', digital_diff_decoder_bb_0_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0_0, '0', digital_diff_decoder_bb_0_0_0_0, '0']
- [digital_constellation_decoder_cb_0_1, '0', digital_diff_decoder_bb_0_1, '0']
- [digital_corr_est_cc_0, '0', virtual_sink_3_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0_1, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', digital_constellation_decoder_cb_0_0_0_0, '0']
- [digital_diff_decoder_bb_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [digital_diff_decoder_bb_0_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_0, '0']
- [digital_diff_decoder_bb_0_1, '0', digital_map_bb_0_0, '0']
- [digital_diff_encoder_bb_0, '0', epy_block_3, '0']
- [digital_diff_encoder_bb_0_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [digital_diff_encoder_bb_0_1, '0', digital_chunks_to_symbols_xx_0_1, '0']
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_header_payload_demux_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_header_payload_demux_0, '1', blocks_selector_0_1, '0']
- [digital_linear_equalizer_0, '0', digital_corr_est_cc_0, '0']
- [digital_linear_equalizer_0, '0', epy_block_1, '0']
- [digital_linear_equalizer_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_0, header_data, digital_header_payload_demux_0, header_data]
- [epy_block_0, len_out, epy_block_2, len_in]
- [epy_block_0, mcs_out, blocks_selector_0_0_0, iindex]
- [epy_block_0, mcs_out, blocks_selector_0_1, oindex]
- [epy_block_0_0, len_out, epy_block_0_0_1, len_in]
- [epy_block_0_0, payload_out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [epy_block_0_0_1, header_out, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [epy_block_0_0_1, mcs_out, blocks_selector_0, oindex]
- [epy_block_0_0_1, mcs_out, blocks_selector_0_0, iindex]
- [epy_block_1, tx_mcs_feedback, virtual_sink_0, '0']
- [epy_block_3, '0', digital_chunks_to_symbols_xx_0, '0']
- [iio_pluto_source_0, '0', analog_agc_xx_0, '0']
- [interp_fir_filter_xxx_0, '0', iio_pluto_sink_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_1, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_selector_0, '0']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_repack_bits_bb_0, '0']
- [qtgui_edit_box_msg_0_0, msg, epy_block_0_0, in]
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', analog_agc_xx_0, '0']
- [virtual_source_1, '0', digital_header_payload_demux_0, '0']
- [virtual_source_1_0, '0', epy_block_0_0_1, mcs_in]
- [virtual_source_1_1, '0', epy_block_2, '0']
- [virtual_source_2, '0', analog_agc_xx_0, '0']
- [virtual_source_3, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
