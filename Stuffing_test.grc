options:
  parameters:
    generate_options: qt_gui
    id: stuffingtest
    output_language: python
    title: stuffingtest
  states: {}

blocks:
- name: flag
  id: variable
  parameters:
    value: '126'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: DLC_CRCCheck_0
  id: DLC_CRCCheck
  parameters:
    scheme: '8'
  states: {}
- name: DLC_CRCGen_0
  id: DLC_CRCGen
  parameters:
    scheme: '8'
  states: {}
- name: DLC_addFlags_0
  id: DLC_addFlags
  parameters:
    bothEnds: 'True'
    flag: flag
  states: {}
- name: DLC_bitStuffing_0
  id: DLC_bitStuffing
  parameters:
    flag: '126'
  states: {}
- name: DLC_deStuffing_0
  id: DLC_deStuffing
  parameters:
    flag: '126'
  states: {}
- name: DLC_removeFlags_0
  id: DLC_removeFlags
  parameters:
    flag: flag
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_1_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '10000'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '17'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: (1,0,1,1,0,1,0,1,1,1,1,1,1,0,1,1,0)
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: As bit stuffing happens before adding the flags, we take unpacked bits as the input
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '1'
    mask: '0xFF'
    maxsize: '2'
    minsize: '1'
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}

connections:
- [DLC_CRCCheck_0, out, pdu_pdu_to_tagged_stream_1, pdus]
- [DLC_CRCGen_0, out, DLC_bitStuffing_0, in]
- [DLC_addFlags_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [DLC_bitStuffing_0, out, DLC_addFlags_0, in]
- [DLC_deStuffing_0, out, DLC_CRCCheck_0, in]
- [DLC_deStuffing_0, out, blocks_message_debug_0_0, print]
- [DLC_removeFlags_0, pdu_out, DLC_deStuffing_0, in]
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [blocks_repack_bits_bb_0, '0', pdu_tagged_stream_to_pdu_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', DLC_removeFlags_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_repack_bits_bb_0, '0']
- [pdu_random_pdu_0, pdus, DLC_CRCGen_0, in]
- [pdu_tagged_stream_to_pdu_1, pdus, blocks_message_debug_0_1, print]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
