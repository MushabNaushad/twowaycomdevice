options:
  parameters:
    author: mushab404
    generate_options: hb
    id: transmitter
    output_language: python
    title: CDP transmitter
  states: {}

blocks:
- name: ADDR
  id: variable
  parameters:
    value: '"192.168.8.1"'
  states: {state: disabled}
- name: CH_GAIN
  id: variable
  parameters:
    value: '30'
  states: {state: disabled}
- name: QPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: SDR_CF
  id: variable
  parameters:
    value: 433e6
  states: {state: disabled}
- name: adpt_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: QPSK_CONST
    modulus: '1'
    step_size: '.0001'
    type: cma
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.45'
  states: {state: disabled}
- name: costas_bw
  id: variable
  parameters:
    value: 2 * pi * 0.01
  states: {state: disabled}
- name: fll_loop_bw
  id: variable
  parameters:
    comment: |-
      Should be small, 
      controls the frequency
      lock to the centre.
    value: 2 * pi * 0.001
  states: {state: disabled}
- name: frequency_offset
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Frequency offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0.025'
  states: {state: disabled}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {state: disabled}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: 'Channel : Noise Voltage'
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {state: disabled}
- name: pi
  id: variable
  parameters:
    value: '3.1415926'
  states: {state: disabled}
- name: rcc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: alpha
    gain: '1'
    ntaps: nfilts*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/float(sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000 '
  states: {state: disabled}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {state: disabled}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Time Offset'
    start: '0.999'
    step: '0.000001'
    stop: '1.001'
    value: '1'
  states: {state: disabled}
- name: ADDR
  id: parameter
  parameters:
    label: SDR ADDRESS
    value: '"192.168.1.1"'
  states: {}
- name: CH_GAIN
  id: parameter
  parameters:
    label: 'SDR: Channel Gain '
    value: '30'
  states: {}
- name: SDR_CF
  id: parameter
  parameters:
    label: SDR Center Frequency
    type: eng_float
    value: 433e6
  states: {}
- name: alpha
  id: parameter
  parameters:
    label: Excess BW
    value: '0.45'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      used to skip head until 
      the filter settles.
    num_items: int(samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 1, 2, 3, 0, 1, 2, 3)
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_volt
    seed: '0'
    taps: '1.0'
  states: {state: disabled}
- name: costas_bw
  id: parameter
  parameters:
    label: Costas Loop BW
    value: 2 * 3.1415926 * 0.01
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK_CONST
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: QPSK_CONST.arity()
    w: costas_bw
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {state: disabled}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: 2* sps +1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: fll_loop_bw
  states: {state: disabled}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: adpt_alg
    num_taps: '11'
    sps: '1'
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: alpha / 10
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {state: disabled}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: rcc_taps
    type: ccc
  states: {state: disabled}
- name: fll_loop_bw
  id: parameter
  parameters:
    label: FLL Loop BW
    type: eng_float
    value: 2 * 3.1415926 * 0.001
  states: {state: disabled}
- name: nfilts
  id: parameter
  parameters:
    label: N Filts
    value: '32'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: decoded_stream
    type: byte
  states: {state: disabled}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: constallation
    type: complex
  states: {state: disabled}
- name: pad_source_0
  id: pad_source
  parameters:
    label: packet_stream
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"tx data"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    name: '"rx data"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Costas"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"TX"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"TX"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"RX"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"RX"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    value: '32000'
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: SDR_CF
    gain: CH_GAIN
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: SDR_CF
    dev_args: '"driver=bladerf"'
    gain: CH_GAIN
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: sps
  id: parameter
  parameters:
    label: Sample per Symbol
    type: intx
    value: '4'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: SDR_CF
    dev_addr: ADDR
    gain0: CH_GAIN
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: SDR_CF
    dev_addr: ADDR
    gain0: CH_GAIN
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: sent_bytes
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx
  states: {state: disabled}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: decoded_rx
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: packet_tx
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: tx
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: tx
  states: {state: disabled}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: rx
  states: {state: disabled}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: decoded_rx
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_random_source_x_0, '0', blocks_copy_0, '0']
- [analog_random_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_copy_0, '0', digital_constellation_modulator_0, '0']
- [blocks_skiphead_0, '0', fft_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', digital_constellation_modulator_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', pad_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_copy_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_vector_source_x_0, '0', virtual_sink_0_0, '0']
- [channels_channel_model_0, '0', virtual_sink_1, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', soapy_bladerf_sink_0, '0']
- [digital_constellation_modulator_0, '0', uhd_usrp_sink_0, '0']
- [digital_constellation_modulator_0, '0', virtual_sink_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', pad_sink_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_1_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_0_1, '0']
- [digital_linear_equalizer_0, '0', qtgui_freq_sink_x_0_1, '0']
- [digital_linear_equalizer_0, '0', qtgui_time_sink_x_0_1, '0']
- [digital_map_bb_0, '0', virtual_sink_2, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [fft_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [pad_source_0, '0', blocks_copy_0, '0']
- [pad_source_0, '0', blocks_throttle2_0, '0']
- [soapy_bladerf_source_0, '0', analog_agc_xx_0, '0']
- [uhd_usrp_source_0, '0', analog_agc_xx_0, '0']
- [virtual_source_0_0, '0', blocks_copy_0, '0']
- [virtual_source_0_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0_0_0, '0', analog_agc_xx_0, '0']
- [virtual_source_1, '0', channels_channel_model_0, '0']
- [virtual_source_1_0, '0', analog_agc_xx_0, '0']
- [virtual_source_2, '0', blocks_unpack_k_bits_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
