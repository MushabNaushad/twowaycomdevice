options:
  parameters:
    author: mushab404
    generate_options: qt_gui
    id: transeciever
    output_language: python
    title: 'CDP transeciever '
  states: {}

blocks:
- name: ADDR
  id: variable
  parameters:
    value: '"ip:192.168.1.10"'
  states: {}
- name: BPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[1+0j, -1+0j]'
    imag_sect: '1'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: CH_GAIN
  id: variable
  parameters:
    value: '20.0'
  states: {}
- name: QPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: SDR_CF
  id: variable
  parameters:
    value: '410000000.0'
  states: {}
- name: adpt_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: QPSK_CONST
    modulus: '1'
    step_size: '.005'
    type: cma
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.45'
  states: {}
- name: amble
  id: variable
  parameters:
    value: '[0xc0, 0xaf]'
  states: {}
- name: amble
  id: variable
  parameters:
    value: '[0xc0, 0xaf]'
  states: {state: disabled}
- name: costas_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: fll_loop_bw
  id: variable
  parameters:
    value: '0.0314'
  states: {}
- name: frequency_offset
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Frequency offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0.005'
  states: {state: disabled}
- name: hdr
  id: variable
  parameters:
    comment: |-
      digital.header_format_default(
          digital.packet_utils.default_access_code, 0)
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: 'Channel : Noise Voltage'
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.1'
  states: {state: disabled}
- name: packets
  id: variable
  parameters:
    value: '50'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.1415926'
  states: {}
- name: postamble_size
  id: variable
  parameters:
    value: '8'
  states: {}
- name: preamble_size
  id: variable
  parameters:
    value: '32'
  states: {}
- name: preamble_symbols
  id: variable
  parameters:
    value: '[1+1j, -1-1j, -1-1j, -1-1j, 1-1j, 1-1j, 1+1j, 1+1j]'
  states: {}
- name: rcc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: alpha
    gain: '1'
    ntaps: nfilts*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/float(sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sym_bw
  id: variable
  parameters:
    value: '0.025'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Time Offset'
    start: '0.999'
    step: '0.000001'
    stop: '1.001'
    value: '1.00001'
  states: {state: disabled}
- name: training_seq
  id: variable
  parameters:
    value: '[1+1j, -1-1j, -1-1j, -1-1j, 1-1j, 1-1j, 1+1j, 1+1j]'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_1
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {}
- name: blocks_copy_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_1_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_3
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_copy_3_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_copy_3_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_copy_4
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_copy_5
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_copy_5_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      used to skip head until 
      the filter settles.
    num_items: int(samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: payload_size
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: preamble_size
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: postamble_size
    type: byte
  states: {state: disabled}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 1, 2, 3, 0, 1, 2, 3)
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: amble
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: amble
  states: {state: disabled}
- name: blocks_vector_source_x_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    tags: ''
    type: byte
    vector: '[p +48 for p in range(packets) for _ in range(payload_size)]'
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_volt
    seed: '0'
    taps: '1.0'
  states: {state: disabled}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK_CONST
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: BPSK_CONST
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: BPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: BPSK_CONST.arity()
    w: costas_bw
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_len
    packed: 'True'
  states: {state: disabled}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: 2* sps +1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: fll_loop_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: adpt_alg
    num_taps: '11'
    sps: '1'
    training_sequence: '[]'
    training_start_tag: '""'
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {state: disabled}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr
    len_tag_key: packet_len
  states: {state: disabled}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: sym_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class TextToPDU(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="Text to PDU",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

          def handle_msg(self, msg):
              # Extract string from PMT message
              if pmt.is_symbol(msg):
                  text = pmt.symbol_to_string(msg)
              elif pmt.is_string(msg):
                  text = pmt.string_to_load(msg)
              else:
                  text = str(pmt.to_python(msg))

              raw_bytes = [ord(c) for c in text]
              meta = pmt.make_dict()
              vec = pmt.init_u8vector(len(raw_bytes), raw_bytes)
              
              # Publish PDU pair: (meta_dict, u8_data_vector)
              self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, vec))
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PacketFramerTX
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import zlib

      class PacketFramerTX(gr.basic_block):
          def __init__(self, my_id="A", peer_id="B", preamble_len=32, postamble_len=16, repeat_count=5):
              gr.basic_block.__init__(
                  self,
                  name="Packet Framer TX",
                  in_sig=None,
                  out_sig=None
              )
              self.my_id = str(my_id)
              self.peer_id = str(peer_id)
              self.preamble_len = preamble_len
              self.postamble_len = postamble_len
              self.repeat_count = int(repeat_count)
              self.sync_word = bytes([0x1A, 0xCF, 0xFC, 0x1D])

              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)
              self.message_port_register_out(pmt.intern("pdu_out"))

          def handle_msg(self, msg):
              py_val = pmt.to_python(msg)
              if isinstance(py_val, tuple):
                  text = bytes(py_val[1]).decode('utf-8', errors='replace')
              else:
                  text = str(py_val)

              if not text:
                  return

              # Prepend addresses if user typed raw text without headers
              if not (">" in text and ":" in text):
                  text = f"{self.my_id}>{self.peer_id}:{text}"

              payload = text.encode('utf-8')
              is_ack = "ACK_" in text
              repeats = 1 if is_ack else self.repeat_count

              # Framing: [Preamble] + [Sync Word] + [Length] + [Payload] + [CRC32] + [Postamble]
              frame = (
                  bytes([0xAA] * self.preamble_len) +
                  self.sync_word +
                  len(payload).to_bytes(2, 'big') +
                  payload +
                  zlib.crc32(payload).to_bytes(4, 'big') +
                  bytes([0xAA] * self.postamble_len)
              )

              vec = pmt.init_u8vector(len(frame), list(frame))
              pdu = pmt.cons(pmt.PMT_NIL, vec)

              for _ in range(repeats):
                  self.message_port_pub(pmt.intern("pdu_out"), pdu)

              if is_ack:
                  print(f"[TX] Sent ACK back to {self.peer_id}", flush=True)
              else:
                  print(f"[TX] Broadcast message to {self.peer_id} ({repeats}x): {text.split(':', 1)[1]}", flush=True)
    my_id: '"A"'
    peer_id: '"B"'
    postamble_len: '16'
    preamble_len: '16'
    repeat_count: '5'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PacketDeframerRX with ACK generation
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import zlib

      class PacketDeframerRX(gr.sync_block):
          STATE_SYNC = 0
          STATE_HEADER = 1
          STATE_PAYLOAD_CRC = 2

          def __init__(self, my_id="A", peer_id="B", max_bit_errors=1, max_payload_len=512):
              gr.sync_block.__init__(
                  self,
                  name="Packet Deframer RX",
                  in_sig=[np.uint8],
                  out_sig=None
              )
              self.my_id = str(my_id)
              self.peer_id = str(peer_id)
              self.max_bit_errors = max_bit_errors
              self.max_payload_len = max_payload_len
              self.sync_target = 0x1ACFFC1D

              self.state = self.STATE_SYNC
              self.shift_reg = 0
              self.bit_buf = 0
              self.bit_count = 0
              self.byte_buf = bytearray()
              self.payload_len = 0
              self.target_bytes = 0

              # Message port to feed ACK back to TX
              self.message_port_register_out(pmt.intern("ack_out"))

          def work(self, input_items, output_items):
              in_bits = input_items[0]

              for bit in in_bits:
                  b = int(bit) & 1

                  if self.state == self.STATE_SYNC:
                      self.shift_reg = ((self.shift_reg << 1) | b) & 0xFFFFFFFF
                      xor_diff = self.shift_reg ^ self.sync_target
                      if bin(xor_diff).count('1') <= self.max_bit_errors:
                          self.state = self.STATE_HEADER
                          self.bit_buf = 0
                          self.bit_count = 0
                          self.byte_buf = bytearray()
                          self.target_bytes = 2

                  elif self.state == self.STATE_HEADER:
                      self.bit_buf = (self.bit_buf << 1) | b
                      self.bit_count += 1
                      if self.bit_count == 8:
                          self.byte_buf.append(self.bit_buf)
                          self.bit_buf = 0
                          self.bit_count = 0
                          if len(self.byte_buf) == self.target_bytes:
                              self.payload_len = int.from_bytes(self.byte_buf, 'big')
                              if 0 < self.payload_len <= self.max_payload_len:
                                  self.state = self.STATE_PAYLOAD_CRC
                                  self.byte_buf = bytearray()
                                  self.target_bytes = self.payload_len + 4
                              else:
                                  self.state = self.STATE_SYNC

                  elif self.state == self.STATE_PAYLOAD_CRC:
                      self.bit_buf = (self.bit_buf << 1) | b
                      self.bit_count += 1
                      if self.bit_count == 8:
                          self.byte_buf.append(self.bit_buf)
                          self.bit_buf = 0
                          self.bit_count = 0
                          if len(self.byte_buf) == self.target_bytes:
                              payload = bytes(self.byte_buf[:self.payload_len])
                              rx_crc = int.from_bytes(self.byte_buf[self.payload_len:], 'big')

                              if rx_crc == zlib.crc32(payload):
                                  msg_str = payload.decode('utf-8', errors='replace')
                                  self._handle_valid_packet(msg_str)

                              self.state = self.STATE_SYNC
                              self.shift_reg = 0

              return len(in_bits)

          def _handle_valid_packet(self, raw_str):
              # Format expectation: SRC>DST:MESSAGE
              if ">" not in raw_str or ":" not in raw_str:
                  return

              header, message = raw_str.split(":", 1)
              src, dst = header.split(">", 1)

              # 1. Reject self-reception (TX bleed)
              if src == self.my_id:
                  return

              # 2. Reject messages directed to other stations
              if dst != self.my_id:
                  return

              # 3. Handle packet
              if message.startswith("ACK_"):
                  print(f"\n>>> [SUCCESS] Peer received: {message[4:]}", flush=True)
              else:
                  print(f"\n========================================", flush=True)
                  print(f"[RX FROM {src}]: {message}", flush=True)
                  print(f"========================================", flush=True)

                  # Auto-respond with ACK (Sent 1x to avoid channel clutter)
                  ack_payload = f"{self.my_id}>{self.peer_id}:ACK_{message}"
                  self.message_port_pub(pmt.intern("ack_out"), pmt.intern(ack_payload))
    max_bit_errors: '1'
    max_payload_len: '4096'
    my_id: '"A"'
    peer_id: '"B"'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: rcc_taps
    type: ccc
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: CH_GAIN
    bandwidth: '20000000'
    buffer_size: '4096'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(SDR_CF)
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '4096'
    filter_source: '''Auto'''
    frequency: int(SDR_CF)
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: '"TX Message"'
    type: string
    value: '"MESSAGE"'
  states: {state: disabled}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: '"TX Message"'
    type: string
    value: '"MESSAGE"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '2048'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/float(sps)
    type: fir_filter_ccf
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: SDR_CF
    dev_args: '"driver=bladerf"'
    gain: CH_GAIN
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: SDR_CF
    dev_args: '"driver=bladerf"'
    gain: CH_GAIN
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    bufflen: '4096'
    center_freq: SDR_CF
    gain: CH_GAIN
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: sent_bytes
  states: {state: disabled}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx
  states: {state: disabled}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {state: disabled}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: decoded_constallation
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: time
  states: {state: disabled}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: freq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: tx
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: tx
  states: {state: disabled}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: rx
  states: {state: disabled}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: decoded_constallation
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: decoded_stream
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: time
  states: {state: disabled}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: freq
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: incoming_packet_stream
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', blocks_copy_1, '0']
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_random_source_x_0, '0', blocks_copy_0, '0']
- [analog_random_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_0_0, '0']
- [analog_random_source_x_1, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_char_to_float_0, '0', virtual_sink_4, '0']
- [blocks_char_to_float_0, '0', virtual_sink_5, '0']
- [blocks_copy_0, '0', digital_constellation_modulator_0, '0']
- [blocks_copy_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_copy_1, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_1_0, '0', blocks_copy_1, '0']
- [blocks_copy_1_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_copy_1_1, '0', analog_agc_xx_0, '0']
- [blocks_copy_1_1, '0', blocks_copy_1_0, '0']
- [blocks_copy_1_2, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_2, '0', digital_costas_loop_cc_0, '0']
- [blocks_copy_3, '0', blocks_unpack_k_bits_bb_1, '0']
- [blocks_copy_3_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_copy_3_1, '0', blocks_copy_3, '0']
- [blocks_copy_3_1, '0', digital_crc32_bb_0, '0']
- [blocks_copy_4, '0', blocks_repack_bits_bb_1, '0']
- [blocks_copy_5, '0', blocks_repack_bits_bb_0, '0']
- [blocks_copy_5_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_copy_5_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_repack_bits_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_repack_bits_bb_1, '0', blocks_copy_3_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_crc32_bb_1, '0']
- [blocks_skiphead_0, '0', fft_filter_xxx_0, '0']
- [blocks_skiphead_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', blocks_copy_3, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', digital_crc32_bb_0, '0']
- [blocks_tag_gate_0, '0', iio_pluto_sink_0, '0']
- [blocks_tag_gate_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_tag_gate_0, '0', virtual_sink_0, '0']
- [blocks_tag_gate_0, '0', virtual_sink_5, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_1, '0']
- [blocks_throttle2_0, '0', digital_constellation_modulator_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_2, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', virtual_sink_2_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_copy_5, '0']
- [blocks_unpack_k_bits_bb_1, '0', digital_scrambler_bb_0, '0']
- [blocks_vector_source_x_0, '0', blocks_copy_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_vector_source_x_0, '0', virtual_sink_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_to_tagged_stream_0_0_0_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_stream_to_tagged_stream_0_0_0_0_0, '0']
- [blocks_vector_source_x_2, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [channels_channel_model_0, '0', virtual_sink_1, '0']
- [dc_blocker_xx_0, '0', analog_agc_xx_0, '0']
- [dc_blocker_xx_0, '0', blocks_copy_1_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_tag_gate_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_tag_gate_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_copy_4, '0']
- [digital_correlate_access_code_xx_ts_0, '0', digital_descrambler_bb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3, '0']
- [digital_crc32_bb_0, '0', blocks_copy_5_0, '0']
- [digital_crc32_bb_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [digital_crc32_bb_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_descrambler_bb_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_copy_1_2, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_scrambler_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_copy_2, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_0, pdu_out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_0_0, pdu_out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [fft_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [iio_pluto_source_0, '0', blocks_copy_1_1, '0']
- [iio_pluto_source_0, '0', dc_blocker_xx_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_copy_3_1, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', virtual_sink_0_1, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [qtgui_edit_box_msg_0, msg, epy_block_0, msg_in]
- [qtgui_edit_box_msg_0_0, msg, epy_block_0_0, msg_in]
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_bladerf_source_0, '0', blocks_copy_1_1, '0']
- [soapy_bladerf_source_0, '0', dc_blocker_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_copy_1_1, '0']
- [virtual_source_0_0, '0', blocks_copy_0, '0']
- [virtual_source_0_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0_0_0, '0', blocks_copy_1_1, '0']
- [virtual_source_0_0_0, '0', dc_blocker_xx_0, '0']
- [virtual_source_1, '0', channels_channel_model_0, '0']
- [virtual_source_1_0, '0', blocks_copy_1_1, '0']
- [virtual_source_1_0, '0', dc_blocker_xx_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0_0, '0']
- [virtual_source_2, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_2_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [virtual_source_2_0, '0', epy_block_0_0_0, '0']
- [virtual_source_3, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_4, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_5, '0', blocks_stream_to_tagged_stream_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
