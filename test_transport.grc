options:
  parameters:
    generate_options: qt_gui
    id: test_transport
    output_language: python
    title: Transport Layer Test
  states: {}

blocks:
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(25, [171, 205, 1, 0, 0, 0, 0, 17] + [ord(c) for c in "Hello from Strobe"]))
    period: '2000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '1000'
    type: complex
  states: {}
- name: transport_transport_layer_0
  id: transport_transport_layer
  parameters:
    m: '4'
    mtu_bytes: '200'
    node_role: '"initiator"'
    rto_ms: '500'
  states: {}
- name: transport_transport_layer_1
  id: transport_transport_layer
  parameters:
    m: '4'
    mtu_bytes: '200'
    node_role: '"responder"'
    rto_ms: '500'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, transport_transport_layer_0, app_in]
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [transport_transport_layer_0, app_out, blocks_message_debug_0, print_pdu]
- [transport_transport_layer_0, pdu_out, transport_transport_layer_1, pdu_in]
- [transport_transport_layer_1, app_out, blocks_message_debug_0, print_pdu]
- [transport_transport_layer_1, pdu_out, transport_transport_layer_0, pdu_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
