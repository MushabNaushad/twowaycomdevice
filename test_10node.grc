options:
  parameters:
    description: 10-node transport layer addressing test on a shared broadcast bus
    generate_options: qt_gui
    id: test_10node
    output_language: python
    title: 10-Node Transport Layer Addressing Test
  states: {}

blocks:
- name: drop_prob
  id: variable_qtgui_range
  parameters:
    comment: Shared bus drop probability (applies to ALL PDUs on the bus)
    gui_hint: 0,0,1,2
    label: '"Bus Drop Prob"'
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.1'
  states: {}
- name: strobe_period_ms
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '1000'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: shared_bus
  id: epy_block
  parameters:
    _source_code: |
      import pmt, random
      from gnuradio import gr

      class blk(gr.basic_block):
          """Shared broadcast bus with configurable loss.
          Every PDU received  on pdu_in is forwarded to pdu_out with probability
          (1 - p_drop). All  10 node pdu_out ports feed into pdu_in; the single
          pdu_out is connected  to all 20 node pdu_in ports."""

          def __init__(self, p_drop=0.1):
              gr.basic_block.__init__(
                  self,
                  name='Shared  Bus',
                  in_sig=None,
                  out_sig=None
              )
              self.p_drop = p_drop
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('pdu_in'),  self.handle_msg)

          def handle_msg(self, msg):
              if random.random()  >= self.p_drop:
                  self.message_port_pub(pmt.intern('pdu_out'),  msg)
    comment: |-
      All node pdu_out → here → all node pdu_in
      Drop prob controlled by  slider
    p_drop: drop_prob
  states: {}
- name: debug_node1
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """Custom labelled message sink"""

          def __init__(self, label="[MSG]"):
              gr.basic_block.__init__(
                  self,
                  name="Labelled Debug",
                  in_sig=None,
                  out_sig=None
              )
              self.label = label
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              print(f"\n{'='*40}")
              print(f"  {self.label}")
              print(f"{'='*40}")
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = pmt.cdr(msg)
                  print(f"  Meta : {pmt.to_python(meta)}")
                  if pmt.is_u8vector(data):
                      raw = bytes(pmt.u8vector_elements(data))
                      print(f"  Bytes: {raw.hex(' ')}")
                      try:
                          print(f"  ASCII: {raw[8:].decode('ascii', errors='replace')}")
                      except:
                          pass
              else:
                  print(f"  {pmt.to_python(msg)}")
    label: '"Node 1 RX"'
  states: {}
- name: debug_node2
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """Custom labelled message sink"""

          def __init__(self, label="[MSG]"):
              gr.basic_block.__init__(
                  self,
                  name="Labelled Debug",
                  in_sig=None,
                  out_sig=None
              )
              self.label = label
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              print(f"\n{'='*40}")
              print(f"  {self.label}")
              print(f"{'='*40}")
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = pmt.cdr(msg)
                  print(f"  Meta : {pmt.to_python(meta)}")
                  if pmt.is_u8vector(data):
                      raw = bytes(pmt.u8vector_elements(data))
                      print(f"  Bytes: {raw.hex(' ')}")
                      try:
                          print(f"  ASCII: {raw[8:].decode('ascii', errors='replace')}")
                      except:
                          pass
              else:
                  print(f"  {pmt.to_python(msg)}")
    label: '"Node 2 RX"'
  states: {}
- name: debug_node3
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """Custom labelled message sink"""

          def __init__(self, label="[MSG]"):
              gr.basic_block.__init__(
                  self,
                  name="Labelled Debug",
                  in_sig=None,
                  out_sig=None
              )
              self.label = label
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              print(f"\n{'='*40}")
              print(f"  {self.label}")
              print(f"{'='*40}")
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = pmt.cdr(msg)
                  print(f"  Meta : {pmt.to_python(meta)}")
                  if pmt.is_u8vector(data):
                      raw = bytes(pmt.u8vector_elements(data))
                      print(f"  Bytes: {raw.hex(' ')}")
                      try:
                          print(f"  ASCII: {raw[8:].decode('ascii', errors='replace')}")
                      except:
                          pass
              else:
                  print(f"  {pmt.to_python(msg)}")
    label: '"Node 3 RX"'
  states: {}
- name: debug_node4
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """Custom labelled message sink"""

          def __init__(self, label="[MSG]"):
              gr.basic_block.__init__(
                  self,
                  name="Labelled Debug",
                  in_sig=None,
                  out_sig=None
              )
              self.label = label
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              print(f"\n{'='*40}")
              print(f"  {self.label}")
              print(f"{'='*40}")
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = pmt.cdr(msg)
                  print(f"  Meta : {pmt.to_python(meta)}")
                  if pmt.is_u8vector(data):
                      raw = bytes(pmt.u8vector_elements(data))
                      print(f"  Bytes: {raw.hex(' ')}")
                      try:
                          print(f"  ASCII: {raw[8:].decode('ascii', errors='replace')}")
                      except:
                          pass
              else:
                  print(f"  {pmt.to_python(msg)}")
    label: '"Node 4 RX"'
  states: {}
- name: debug_node5
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """Custom labelled message sink"""

          def __init__(self, label="[MSG]"):
              gr.basic_block.__init__(
                  self,
                  name="Labelled Debug",
                  in_sig=None,
                  out_sig=None
              )
              self.label = label
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              print(f"\n{'='*40}")
              print(f"  {self.label}")
              print(f"{'='*40}")
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = pmt.cdr(msg)
                  print(f"  Meta : {pmt.to_python(meta)}")
                  if pmt.is_u8vector(data):
                      raw = bytes(pmt.u8vector_elements(data))
                      print(f"  Bytes: {raw.hex(' ')}")
                      try:
                          print(f"  ASCII: {raw[8:].decode('ascii', errors='replace')}")
                      except:
                          pass
              else:
                  print(f"  {pmt.to_python(msg)}")
    label: '"Node 5 RX"'
  states: {}
- name: debug_node6
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """Custom labelled message sink"""

          def __init__(self, label="[MSG]"):
              gr.basic_block.__init__(
                  self,
                  name="Labelled Debug",
                  in_sig=None,
                  out_sig=None
              )
              self.label = label
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              print(f"\n{'='*40}")
              print(f"  {self.label}")
              print(f"{'='*40}")
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = pmt.cdr(msg)
                  print(f"  Meta : {pmt.to_python(meta)}")
                  if pmt.is_u8vector(data):
                      raw = bytes(pmt.u8vector_elements(data))
                      print(f"  Bytes: {raw.hex(' ')}")
                      try:
                          print(f"  ASCII: {raw[8:].decode('ascii', errors='replace')}")
                      except:
                          pass
              else:
                  print(f"  {pmt.to_python(msg)}")
    label: '"Node 6 RX"'
  states: {}
- name: debug_node7
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """Custom labelled message sink"""

          def __init__(self, label="[MSG]"):
              gr.basic_block.__init__(
                  self,
                  name="Labelled Debug",
                  in_sig=None,
                  out_sig=None
              )
              self.label = label
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              print(f"\n{'='*40}")
              print(f"  {self.label}")
              print(f"{'='*40}")
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = pmt.cdr(msg)
                  print(f"  Meta : {pmt.to_python(meta)}")
                  if pmt.is_u8vector(data):
                      raw = bytes(pmt.u8vector_elements(data))
                      print(f"  Bytes: {raw.hex(' ')}")
                      try:
                          print(f"  ASCII: {raw[8:].decode('ascii', errors='replace')}")
                      except:
                          pass
              else:
                  print(f"  {pmt.to_python(msg)}")
    label: '"Node 7 RX"'
  states: {}
- name: debug_node8
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """Custom labelled message sink"""

          def __init__(self, label="[MSG]"):
              gr.basic_block.__init__(
                  self,
                  name="Labelled Debug",
                  in_sig=None,
                  out_sig=None
              )
              self.label = label
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              print(f"\n{'='*40}")
              print(f"  {self.label}")
              print(f"{'='*40}")
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = pmt.cdr(msg)
                  print(f"  Meta : {pmt.to_python(meta)}")
                  if pmt.is_u8vector(data):
                      raw = bytes(pmt.u8vector_elements(data))
                      print(f"  Bytes: {raw.hex(' ')}")
                      try:
                          print(f"  ASCII: {raw[8:].decode('ascii', errors='replace')}")
                      except:
                          pass
              else:
                  print(f"  {pmt.to_python(msg)}")
    label: '"Node 8 RX"'
  states: {}
- name: debug_node9
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """Custom labelled message sink"""

          def __init__(self, label="[MSG]"):
              gr.basic_block.__init__(
                  self,
                  name="Labelled Debug",
                  in_sig=None,
                  out_sig=None
              )
              self.label = label
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              print(f"\n{'='*40}")
              print(f"  {self.label}")
              print(f"{'='*40}")
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = pmt.cdr(msg)
                  print(f"  Meta : {pmt.to_python(meta)}")
                  if pmt.is_u8vector(data):
                      raw = bytes(pmt.u8vector_elements(data))
                      print(f"  Bytes: {raw.hex(' ')}")
                      try:
                          print(f"  ASCII: {raw[8:].decode('ascii', errors='replace')}")
                      except:
                          pass
              else:
                  print(f"  {pmt.to_python(msg)}")
    label: '"Node 9 RX"'
  states: {}
- name: debug_node10
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """Custom labelled message sink"""

          def __init__(self, label="[MSG]"):
              gr.basic_block.__init__(
                  self,
                  name="Labelled Debug",
                  in_sig=None,
                  out_sig=None
              )
              self.label = label
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              print(f"\n{'='*40}")
              print(f"  {self.label}")
              print(f"{'='*40}")
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = pmt.cdr(msg)
                  print(f"  Meta : {pmt.to_python(meta)}")
                  if pmt.is_u8vector(data):
                      raw = bytes(pmt.u8vector_elements(data))
                      print(f"  Bytes: {raw.hex(' ')}")
                      try:
                          print(f"  ASCII: {raw[8:].decode('ascii', errors='replace')}")
                      except:
                          pass
              else:
                  print(f"  {pmt.to_python(msg)}")
    label: '"Node 10 RX"'
  states: {}
- name: ini_node1
  id: transport_transport_layer
  parameters:
    comment: Initiator — addr=1
    local_addr: '1'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"initiator"'
    rto_ms: '600'
  states: {}
- name: ini_node2
  id: transport_transport_layer
  parameters:
    comment: Initiator — addr=2
    local_addr: '2'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"initiator"'
    rto_ms: '600'
  states: {}
- name: ini_node3
  id: transport_transport_layer
  parameters:
    comment: Initiator — addr=3
    local_addr: '3'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"initiator"'
    rto_ms: '600'
  states: {}
- name: ini_node4
  id: transport_transport_layer
  parameters:
    comment: Initiator — addr=4
    local_addr: '4'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"initiator"'
    rto_ms: '600'
  states: {}
- name: ini_node5
  id: transport_transport_layer
  parameters:
    comment: Initiator — addr=5
    local_addr: '5'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"initiator"'
    rto_ms: '600'
  states: {}
- name: ini_node6
  id: transport_transport_layer
  parameters:
    comment: Initiator — addr=6
    local_addr: '6'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"initiator"'
    rto_ms: '600'
  states: {}
- name: ini_node7
  id: transport_transport_layer
  parameters:
    comment: Initiator — addr=7
    local_addr: '7'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"initiator"'
    rto_ms: '600'
  states: {}
- name: ini_node8
  id: transport_transport_layer
  parameters:
    comment: Initiator — addr=8
    local_addr: '8'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"initiator"'
    rto_ms: '600'
  states: {}
- name: ini_node9
  id: transport_transport_layer
  parameters:
    comment: Initiator — addr=9
    local_addr: '9'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"initiator"'
    rto_ms: '600'
  states: {}
- name: ini_node10
  id: transport_transport_layer
  parameters:
    comment: Initiator — addr=10
    local_addr: '10'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"initiator"'
    rto_ms: '600'
  states: {}
- name: rsp_node1
  id: transport_transport_layer
  parameters:
    comment: Responder — addr=1
    local_addr: '1'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"responder"'
    rto_ms: '600'
  states: {}
- name: rsp_node2
  id: transport_transport_layer
  parameters:
    comment: Responder — addr=2
    local_addr: '2'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"responder"'
    rto_ms: '600'
  states: {}
- name: rsp_node3
  id: transport_transport_layer
  parameters:
    comment: Responder — addr=3
    local_addr: '3'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"responder"'
    rto_ms: '600'
  states: {}
- name: rsp_node4
  id: transport_transport_layer
  parameters:
    comment: Responder — addr=4
    local_addr: '4'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"responder"'
    rto_ms: '600'
  states: {}
- name: rsp_node5
  id: transport_transport_layer
  parameters:
    comment: Responder — addr=5
    local_addr: '5'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"responder"'
    rto_ms: '600'
  states: {}
- name: rsp_node6
  id: transport_transport_layer
  parameters:
    comment: Responder — addr=6
    local_addr: '6'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"responder"'
    rto_ms: '600'
  states: {}
- name: rsp_node7
  id: transport_transport_layer
  parameters:
    comment: Responder — addr=7
    local_addr: '7'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"responder"'
    rto_ms: '600'
  states: {}
- name: rsp_node8
  id: transport_transport_layer
  parameters:
    comment: Responder — addr=8
    local_addr: '8'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"responder"'
    rto_ms: '600'
  states: {}
- name: rsp_node9
  id: transport_transport_layer
  parameters:
    comment: Responder — addr=9
    local_addr: '9'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"responder"'
    rto_ms: '600'
  states: {}
- name: rsp_node10
  id: transport_transport_layer
  parameters:
    comment: Responder — addr=10
    local_addr: '10'
    local_port: '0'
    m: '4'
    mtu_bytes: '200'
    node_role: '"responder"'
    rto_ms: '600'
  states: {}
- name: strobe_node1
  id: blocks_message_strobe
  parameters:
    comment: |-
      Node 1 (addr=1) → Node 6 (addr=6)
      type=text, fires every 8s
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(8 + 19, [6, 0, 1, 0, 0, 0,  0, 19] + [ord(c) for c in "Hello from Node 1!"]))
    period: strobe_period_ms
  states: {}
- name: strobe_node2
  id: blocks_message_strobe
  parameters:
    comment: |-
      Node 2 (addr=2) → Node 7 (addr=7)
      type=text, fires every 8s
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(8 + 19, [7, 0, 1, 0, 0, 0,  0, 19] + [ord(c) for c in "Hello from Node 2!"]))
    period: strobe_period_ms
  states: {}
- name: strobe_node3
  id: blocks_message_strobe
  parameters:
    comment: |-
      Node 3 (addr=3) → Node 8 (addr=8)
      type=text, fires every 8s
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(8 + 19, [8, 0, 1, 0, 0, 0,  0, 19] + [ord(c) for c in "Hello from Node 3!"]))
    period: strobe_period_ms
  states: {}
- name: strobe_node4
  id: blocks_message_strobe
  parameters:
    comment: |-
      Node 4 (addr=4) → Node 9 (addr=9)
      type=text, fires every 8s
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(8 + 19, [9, 0, 1, 0, 0, 0,  0, 19] + [ord(c) for c in "Hello from Node 4!"]))
    period: strobe_period_ms
  states: {}
- name: strobe_node5
  id: blocks_message_strobe
  parameters:
    comment: |-
      Node 5 (addr=5) → Node 10 (addr=10)
      type=text, fires every 8s
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(8 + 19, [10, 0, 1, 0, 0, 0,  0, 19] + [ord(c) for c in "Hello from Node 5!"]))
    period: strobe_period_ms
  states: {}
- name: strobe_node6
  id: blocks_message_strobe
  parameters:
    comment: |-
      Node 6 (addr=6) → Node 1 (addr=1)
      type=text, fires every 8s
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(8 + 19, [1, 0, 1, 0, 0, 0,  0, 19] + [ord(c) for c in "Hello from Node 6!"]))
    period: strobe_period_ms
  states: {}
- name: strobe_node7
  id: blocks_message_strobe
  parameters:
    comment: |-
      Node 7 (addr=7) → Node 2 (addr=2)
      type=text, fires every 8s
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(8 + 19, [2, 0, 1, 0, 0, 0,  0, 19] + [ord(c) for c in "Hello from Node 7!"]))
    period: strobe_period_ms
  states: {}
- name: strobe_node8
  id: blocks_message_strobe
  parameters:
    comment: |-
      Node 8 (addr=8) → Node 3 (addr=3)
      type=text, fires every 8s
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(8 + 19, [3, 0, 1, 0, 0, 0,  0, 19] + [ord(c) for c in "Hello from Node 8!"]))
    period: strobe_period_ms
  states: {}
- name: strobe_node9
  id: blocks_message_strobe
  parameters:
    comment: |-
      Node 9 (addr=9) → Node 4 (addr=4)
      type=text, fires every 8s
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(8 + 19, [4, 0, 1, 0, 0, 0,  0, 19] + [ord(c) for c in "Hello from Node 9!"]))
    period: strobe_period_ms
  states: {}
- name: strobe_node10
  id: blocks_message_strobe
  parameters:
    comment: |-
      Node 10 (addr=10) → Node 5 (addr=5)
      type=text, fires every 8s
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(8 + 20, [5, 0, 1, 0, 0, 0,  0, 20] + [ord(c) for c in "Hello from Node 10!"]))
    period: strobe_period_ms
  states: {}
- name: debug_ini_node1
  id: blocks_message_debug
  parameters:
    comment: ini_node1 app_out (unused for normal send)
  states: {}
- name: debug_ini_node2
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: debug_ini_node3
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: debug_ini_node4
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: debug_ini_node5
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: debug_ini_node6
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: debug_ini_node7
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: debug_ini_node8
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: debug_ini_node9
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: debug_ini_node10
  id: blocks_message_debug
  parameters: {}
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [strobe_node1, strobe, ini_node1, app_in]
- [strobe_node2, strobe, ini_node2, app_in]
- [strobe_node3, strobe, ini_node3, app_in]
- [strobe_node4, strobe, ini_node4, app_in]
- [strobe_node5, strobe, ini_node5, app_in]
- [strobe_node6, strobe, ini_node6, app_in]
- [strobe_node7, strobe, ini_node7, app_in]
- [strobe_node8, strobe, ini_node8, app_in]
- [strobe_node9, strobe, ini_node9, app_in]
- [strobe_node10, strobe, ini_node10, app_in]
- [ini_node1, pdu_out, shared_bus, pdu_in]
- [ini_node2, pdu_out, shared_bus, pdu_in]
- [ini_node3, pdu_out, shared_bus, pdu_in]
- [ini_node4, pdu_out, shared_bus, pdu_in]
- [ini_node5, pdu_out, shared_bus, pdu_in]
- [ini_node6, pdu_out, shared_bus, pdu_in]
- [ini_node7, pdu_out, shared_bus, pdu_in]
- [ini_node8, pdu_out, shared_bus, pdu_in]
- [ini_node9, pdu_out, shared_bus, pdu_in]
- [ini_node10, pdu_out, shared_bus, pdu_in]
- [rsp_node1, pdu_out, shared_bus, pdu_in]
- [rsp_node2, pdu_out, shared_bus, pdu_in]
- [rsp_node3, pdu_out, shared_bus, pdu_in]
- [rsp_node4, pdu_out, shared_bus, pdu_in]
- [rsp_node5, pdu_out, shared_bus, pdu_in]
- [rsp_node6, pdu_out, shared_bus, pdu_in]
- [rsp_node7, pdu_out, shared_bus, pdu_in]
- [rsp_node8, pdu_out, shared_bus, pdu_in]
- [rsp_node9, pdu_out, shared_bus, pdu_in]
- [rsp_node10, pdu_out, shared_bus, pdu_in]
- [shared_bus, pdu_out, ini_node1, pdu_in]
- [shared_bus, pdu_out, ini_node2, pdu_in]
- [shared_bus, pdu_out, ini_node3, pdu_in]
- [shared_bus, pdu_out, ini_node4, pdu_in]
- [shared_bus, pdu_out, ini_node5, pdu_in]
- [shared_bus, pdu_out, ini_node6, pdu_in]
- [shared_bus, pdu_out, ini_node7, pdu_in]
- [shared_bus, pdu_out, ini_node8, pdu_in]
- [shared_bus, pdu_out, ini_node9, pdu_in]
- [shared_bus, pdu_out, ini_node10, pdu_in]
- [shared_bus, pdu_out, rsp_node1, pdu_in]
- [shared_bus, pdu_out, rsp_node2, pdu_in]
- [shared_bus, pdu_out, rsp_node3, pdu_in]
- [shared_bus, pdu_out, rsp_node4, pdu_in]
- [shared_bus, pdu_out, rsp_node5, pdu_in]
- [shared_bus, pdu_out, rsp_node6, pdu_in]
- [shared_bus, pdu_out, rsp_node7, pdu_in]
- [shared_bus, pdu_out, rsp_node8, pdu_in]
- [shared_bus, pdu_out, rsp_node9, pdu_in]
- [shared_bus, pdu_out, rsp_node10, pdu_in]
- [rsp_node1, app_out, debug_node1, in]
- [rsp_node2, app_out, debug_node2, in]
- [rsp_node3, app_out, debug_node3, in]
- [rsp_node4, app_out, debug_node4, in]
- [rsp_node5, app_out, debug_node5, in]
- [rsp_node6, app_out, debug_node6, in]
- [rsp_node7, app_out, debug_node7, in]
- [rsp_node8, app_out, debug_node8, in]
- [rsp_node9, app_out, debug_node9, in]
- [rsp_node10, app_out, debug_node10, in]
- [ini_node1, app_out, debug_ini_node1, store]
- [ini_node2, app_out, debug_ini_node2, store]
- [ini_node3, app_out, debug_ini_node3, store]
- [ini_node4, app_out, debug_ini_node4, store]
- [ini_node5, app_out, debug_ini_node5, store]
- [ini_node6, app_out, debug_ini_node6, store]
- [ini_node7, app_out, debug_ini_node7, store]
- [ini_node8, app_out, debug_ini_node8, store]
- [ini_node9, app_out, debug_ini_node9, store]
- [ini_node10, app_out, debug_ini_node10, store]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
