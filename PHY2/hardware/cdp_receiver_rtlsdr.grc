options:
  parameters:
    author: mushab404
    description: PHY2 Dedicated RTL-SDR BPSK Receiver
    generate_options: qt_gui
    id: cdp_receiver_rtlsdr
    output_language: python
    title: PHY2 CDP RTL-SDR Receiver
  states: {}

blocks:
- name: SDR_CF
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Center Frequency (Hz)
    start: 24e6
    step: 1e5
    stop: 1.7e9
    value: 433.98e6
  states: {}
- name: RX_GAIN
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: RTL-SDR Gain (dB)
    start: '0'
    step: '1'
    stop: '49'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: fll_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: FLL Loop BW
    start: '0.001'
    step: '0.002'
    stop: '0.1'
    value: '0.0314'
  states: {}
- name: costas_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Costas Loop BW
    start: '0.01'
    step: '0.005'
    stop: '0.2'
    value: '0.0628'
  states: {}
- name: rcc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: alpha
    gain: '1.0'
    ntaps: 32*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: BPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[-1+0j, 1+0j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: SDR_CF
    dev_args: '"driver=rtlsdr"'
    gain: RX_GAIN
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-2'
    reference: '1.0'
    type: complex
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: 2*sps+1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: fll_loop_bw
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: rcc_taps
    type: ccc
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: costas_bw
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,2
    label1: RTL-SDR Constellation
    size: '1024'
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: BPSK_CONST
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: '"packet_len"'
    threshold: '2'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    length_tag_key: '"packet_len"'
    packed: 'True'
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"packet_len"'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', analog_agc_xx_0, '0']
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [digital_fll_band_edge_cc_0, '0', fft_filter_xxx_0, '0']
- [fft_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_crc32_bb_1, '0']
- [digital_crc32_bb_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print_pdu]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
